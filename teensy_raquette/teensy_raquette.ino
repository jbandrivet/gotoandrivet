/*
 * GotoAndrivet - Teensy 4.1 Raquette
 * Auteur : Andrivet Jean-Baptiste
 * Firmware UI (LCD + boutons)
 * 
 * Cablage RJ11 (Teensy raquette <-> Mega) :
 *
 *   Pin RJ11   Signal                    Connexion
 *   -------    ------                    ---------
 *     1        GND                       Mega GND  <-> Teensy GND
 *     2        5V  (alim Teensy)         Mega 5V    -> Teensy VIN
 *     3        TX  (Teensy -> Mega)      Teensy Pin 1 (TX1) -> Mega Pin 15 (RX3)
 *     4        RX  (Mega -> Teensy)      Mega Pin 14 (TX3)  -> Teensy Pin 0 (RX1)
 *
 * ALIMENTATION : Le Teensy est alimente par la pin 5V du Mega via VIN.
 *   Le Mega doit etre alimente par barrel jack (7-12V) pour fournir
 *   assez de courant (regulateur ~800mA, conso totale ~250mA).
 *   ATTENTION : ne pas brancher l'USB du Teensy en meme temps que le
 *   VIN est alimente, sauf si le pad VUSB est coupe sur le Teensy.
 */

#include <Arduino.h>
#include <Wire.h>
#include <LiquidCrystal_I2C.h>
#include <EEPROM.h>
#include <new>
#include "mini_ephem.h"

enum CatID { CAT_MESSIER=0, CAT_NGC, CAT_IC, CAT_PK, CAT_CALDWELL, CAT_BSC, CAT_SYSSOL, CAT_COUNT };
bool isEnglish = false;
bool displayRaDec = true;
bool temp_displayRaDec = true;
#define CHAR_LEFT  0x7F
#define CHAR_RIGHT 0x7E

int dt_y=2026, dt_m=1, dt_d=1;
int dt_hr=12, dt_min=0, dt_sec=0;
double utcOffLx = 0.0;   // :GG de la monture (LX200) : heures a ajouter a l'heure locale pour obtenir l'UTC
int cgo_ra_h=0, cgo_ra_m=0, cgo_ra_s=0;
int cgo_dec_d=0, cgo_dec_m=0, cgo_dec_s=0;
bool cgo_dec_neg=false;
float obs_lat=45.0, obs_lon=0.0;
bool timeFetched = false;

// ============================================================
// SECTION CATALOGUES ASTRONOMIQUES (intégrés en PROGMEM)
// ============================================================

#define OBJ_GALAXY       0
#define OBJ_OPEN_CLUSTER 1
#define OBJ_GLOB_CLUSTER 2
#define OBJ_NEBULA       3
#define OBJ_PLAN_NEBULA  4
#define OBJ_SUPERNOVA    5
#define OBJ_DOUBLE_STAR  6
#define OBJ_ASTERISM     7
#define OBJ_STAR         8

struct DeepSkyObject {
    uint16_t id;
    float    ra;    
    float    dec;   
    int16_t  mag;   
    uint8_t  type;
};

struct StarObject {
    uint16_t id;
    float    ra;
    float    dec;
    int16_t  mag;   
    uint8_t  type;  
    char     name[12];
};

const char* const typeGal = "Galaxie     ";
const char typeOC[]  PROGMEM = "Amas ouvert ";
const char typeGC[]  PROGMEM = "Amas globul.";
const char* const typeNeb = "Nebuleuse   ";
const char typePN[]  PROGMEM = "Neb.Planet. ";
const char typeSN[]  PROGMEM = "Reste SNova ";
const char typeDS[]  PROGMEM = "Etoile dble ";
const char* const typeAst = "Asterisme   ";
const char typeStar[] PROGMEM= "Etoile      ";

const char* const OBJ_TYPE_NAMES[] = {
    typeGal, typeOC, typeGC, typeNeb, typePN, typeSN, typeDS, typeAst, typeStar
};

const char* getTypeName(uint8_t type) {
    if (type >= 9) type = 0;
    if (isEnglish) {
        const char* const OBJ_TYPE_NAMES_EN[] = {
            "Galaxy      ", "Open Cluster", "Glob.Cluster", "Nebula      ", "Plan.Nebula ", "Supernova R.", "Double Star ", "Asterism    ", "Star        "
        };
        return OBJ_TYPE_NAMES_EN[type];
    }
    return OBJ_TYPE_NAMES[type];
}

// ---------- M 110 objets ----------
const DeepSkyObject catalogM[] PROGMEM = {
    {    1,    5.5756f,   22.0144f,   85, 5},
    {    2,   21.5575f,   -0.8233f,   63, 2},
    {    3,   13.7031f,   28.3756f,   62, 2},
    {    4,   16.3931f,  -26.5253f,   56, 2},
    {    5,   15.3092f,    2.0828f,   65, 2},
    {    6,   17.6725f,  -32.2189f,   51, 1},
    {    7,   17.8975f,  -34.7928f,   33, 1},
    {    8,   18.0603f,  -24.3867f,   60, 3},
    {    9,   17.3200f,  -18.5161f,   78, 2},
    {   10,   16.9525f,   -4.0994f,   66, 2},
    {   11,   18.8514f,   -6.2667f,   58, 1},
    {   12,   16.7872f,   -1.9483f,   68, 2},
    {   13,   16.6947f,   36.4614f,   58, 2},
    {   14,   17.6267f,   -3.2458f,   77, 2},
    {   15,   21.4994f,   12.1669f,   62, 2},
    {   16,   18.3072f,  -13.7789f,   60, 1},
    {   17,   18.3406f,  -16.1767f,   60, 3},
    {   18,   18.3328f,  -17.1017f,   69, 1},
    {   19,   17.0436f,  -26.2681f,   70, 2},
    {   20,   18.0283f,  -23.0300f,   82, 3},
    {   21,   18.0703f,  -22.4900f,   58, 1},
    {   22,   18.6067f,  -23.9033f,   51, 2},
    {   23,   17.9483f,  -19.0167f,   52, 1},
    {   24,   18.2833f,  -18.5333f,   45, 1},
    {   25,   18.5297f,  -19.1167f,   46, 1},
    {   26,   18.7550f,   -9.3833f,   80, 1},
    {   27,   19.9933f,   22.7211f,   74, 4},
    {   28,   18.4089f,  -24.8700f,   78, 2},
    {   29,   20.3989f,   38.5333f,   71, 1},
    {   30,   21.6728f,  -23.1792f,   72, 2},
    {   31,    0.7122f,   41.2692f,   35, 0},
    {   32,    0.7117f,   40.8653f,   82, 0},
    {   33,    1.5642f,   30.6603f,   59, 0},
    {   34,    2.7014f,   42.7833f,   51, 1},
    {   35,    6.1483f,   24.3333f,   52, 1},
    {   36,    5.6017f,   34.1333f,   60, 1},
    {   37,    5.8717f,   32.5533f,   56, 1},
    {   38,    5.4786f,   35.8333f,   67, 1},
    {   39,   21.5300f,   48.4333f,   49, 1},
    {   40,   12.3700f,   58.0833f,   90, 6},
    {   41,    6.7667f,  -20.7333f,   44, 1},
    {   42,    5.5881f,   -5.3911f,   40, 3},
    {   43,    5.5919f,   -5.2675f,   90, 3},
    {   44,    8.6683f,   19.9833f,   33, 1},
    {   45,    3.7900f,   24.1167f,   12, 1},
    {   46,    7.6961f,  -14.8100f,   60, 1},
    {   47,    7.6097f,  -14.4833f,   43, 1},
    {   48,    8.2286f,   -5.7500f,   55, 1},
    {   49,   12.4964f,    8.0003f,   83, 0},
    {   50,    7.0450f,   -8.3833f,   56, 1},
    {   51,   13.4981f,   47.1953f,   83, 0},
    {   52,   23.4133f,   61.5933f,   72, 1},
    {   53,   13.2153f,   18.1681f,   76, 2},
    {   54,   18.9175f,  -30.4783f,   78, 2},
    {   55,   19.6664f,  -30.9647f,   70, 2},
    {   56,   19.2764f,   30.1847f,   84, 2},
    {   57,   18.8931f,   33.0292f,   89, 4},
    {   58,   12.6286f,   11.8181f,   95, 0},
    {   59,   12.6997f,   11.6469f,   95, 0},
    {   60,   12.7278f,   11.5525f,   88, 0},
    {   61,   12.3653f,    4.4736f,   95, 0},
    {   62,   17.0200f,  -30.1125f,   68, 2},
    {   63,   13.2636f,   42.0292f,   88, 0},
    {   64,   12.9456f,   21.6831f,   86, 0},
    {   65,   11.3156f,   13.0922f,   97, 0},
    {   66,   11.3375f,   12.9914f,   89, 0},
    {   67,    8.8550f,   11.8000f,   68, 1},
    {   68,   12.6578f,  -26.7428f,   78, 2},
    {   69,   18.5231f,  -32.3481f,   77, 2},
    {   70,   18.7200f,  -32.2919f,   79, 2},
    {   71,   19.8961f,   18.7792f,   82, 2},
    {   72,   20.8911f,  -12.5372f,   91, 2},
    {   73,   20.9822f,  -12.6356f,   90, 7},
    {   74,    1.6117f,   15.7836f,   99, 0},
    {   75,   20.1011f,  -21.9211f,   86, 2},
    {   76,    1.7056f,   51.5753f,  101, 4},
    {   77,    2.7114f,   -0.0133f,   89, 0},
    {   78,    5.7794f,    0.0511f,   80, 3},
    {   79,    5.4031f,  -24.5242f,   77, 2},
    {   80,   16.2842f,  -22.9758f,   72, 2},
    {   81,    9.9258f,   69.0653f,   68, 0},
    {   82,    9.9311f,   69.6797f,   87, 0},
    {   83,   13.6167f,  -29.8653f,   77, 0},
    {   84,   12.4178f,   12.8869f,   93, 0},
    {   85,   12.4233f,   18.1911f,   90, 0},
    {   86,   12.4367f,   12.9456f,   89, 0},
    {   87,   12.5136f,   12.3911f,   87, 0},
    {   88,   12.5331f,   14.4206f,   95, 0},
    {   89,   12.5944f,   12.5564f,   97, 0},
    {   90,   12.6136f,   13.1628f,   93, 0},
    {   91,   12.5906f,   14.4964f,  103, 0},
    {   92,   17.2853f,   43.1358f,   62, 2},
    {   93,    7.7417f,  -23.8531f,   60, 1},
    {   94,   12.8481f,   41.1206f,   83, 0},
    {   95,   10.7328f,   11.7039f,   97, 0},
    {   96,   10.7794f,   11.8200f,   97, 0},
    {   97,   11.2467f,   55.0192f,   97, 4},
    {   98,   12.2300f,   14.9003f,  101, 0},
    {   99,   12.3139f,   14.4164f,   97, 0},
    {  100,   12.3819f,   15.8225f,   93, 0},
    {  101,   14.0536f,   54.3489f,   77, 0},
    {  102,   15.1081f,   55.7631f,  100, 0},
    {  103,    1.5558f,   60.6583f,   71, 1},
    {  104,   12.6664f,  -11.6231f,   80, 0},
    {  105,   10.7969f,   12.5817f,   93, 0},
    {  106,   12.3161f,   47.3039f,   83, 0},
    {  107,   16.5422f,  -13.0536f,   82, 2},
    {  108,   11.1919f,   55.6742f,  100, 0},
    {  109,   11.9600f,   53.3744f,   99, 0},
    {  110,    0.6728f,   41.6853f,   81, 0},
};
const uint16_t MESSIER_COUNT = 110;

// ---------- NGC 521 objets ----------
const DeepSkyObject catalogNGC[] PROGMEM = {
    {   55,    0.2483f,  -39.1970f,   80, 0},
    {  147,    0.5508f,   48.5080f,  102, 0},
    {  185,    0.6492f,   48.3370f,   99, 0},
    {  205,    0.6733f,   41.6830f,   81, 0},
    {  221,    0.7117f,   40.8670f,   82, 0},
    {  224,    0.7122f,   41.2690f,   35, 0},
    {  247,    0.7847f,  -20.7610f,   90, 0},
    {  253,    0.7925f,  -25.2880f,   72, 0},
    {  300,    0.9147f,  -37.6830f,   85, 0},
    {  598,    1.5642f,   30.6600f,   59, 0},
    {  628,    1.5867f,   15.7830f,   99, 0},
    {  772,    1.9808f,   19.0170f,  102, 0},
    {  891,    2.3742f,   42.3500f,  100, 0},
    {  908,    2.4008f,  -21.2330f,   99, 0},
    {  925,    2.4517f,   33.5780f,  102, 0},
    {  936,    2.4658f,   -1.1560f,  103, 0},
    { 1022,    2.6600f,   -6.6780f,  117, 0},
    { 1023,    2.6667f,   39.0670f,   93, 0},
    { 1052,    2.6992f,   -8.2560f,  107, 0},
    { 1055,    2.7000f,    0.4330f,  105, 0},
    { 1084,    2.7617f,   -7.5780f,  103, 0},
    { 1232,    3.1625f,  -20.5830f,   99, 0},
    { 1291,    3.2875f,  -41.1080f,   90, 0},
    { 1300,    3.3158f,  -19.4170f,  105, 0},
    { 1313,    3.3042f,  -66.4980f,   89, 0},
    { 1316,    3.3792f,  -37.2170f,   89, 0},
    { 1332,    3.4317f,  -21.3310f,  106, 0},
    { 1350,    3.5125f,  -33.6170f,  107, 0},
    { 1365,    3.5558f,  -36.1330f,   97, 0},
    { 1380,    3.5958f,  -34.9780f,  106, 0},
    { 1398,    3.6342f,  -26.3360f,   99, 0},
    { 1399,    3.6417f,  -35.4500f,   97, 0},
    { 1404,    3.6508f,  -35.5940f,  101, 0},
    { 1407,    3.6567f,  -18.5780f,   97, 0},
    { 1425,    3.7000f,  -29.8970f,  112, 0},
    { 1433,    3.6017f,  -47.2220f,   99, 0},
    { 1512,    4.0375f,  -43.3480f,  101, 0},
    { 1521,    4.0975f,  -21.0500f,  113, 0},
    { 1532,    4.1225f,  -32.8720f,  107, 0},
    { 1549,    4.1792f,  -55.5970f,  100, 0},
    { 1553,    4.1875f,  -55.7810f,   97, 0},
    { 1566,    4.2825f,  -54.9380f,   97, 0},
    { 1700,    4.8692f,   -4.8670f,  111, 0},
    { 1792,    5.0600f,  -37.9830f,   99, 0},
    { 1808,    5.1325f,  -37.5140f,   97, 0},
    { 2613,    8.5842f,  -22.9750f,  103, 0},
    { 2683,    8.7267f,   33.4220f,   97, 0},
    { 2742,    9.0717f,   60.4780f,  116, 0},
    { 2768,    9.1308f,   60.0360f,  100, 0},
    { 2775,    9.1650f,    7.0360f,  102, 0},
    { 2784,    9.1817f,  -24.1720f,  100, 0},
    { 2787,    9.1958f,   69.2030f,  111, 0},
    { 2841,    9.3750f,   50.9830f,   93, 0},
    { 2855,    9.4167f,  -11.8940f,  118, 0},
    { 2903,    9.5217f,   21.5000f,   89, 0},
    { 2950,    9.6892f,   58.8500f,  116, 0},
    { 2955,    9.7017f,   35.8830f,  120, 0},
    { 2976,    9.7475f,   67.9000f,  102, 0},
    { 2985,    9.7733f,   72.2780f,  114, 0},
    { 3003,    9.8283f,   33.4330f,  122, 0},
    { 3031,    9.9258f,   69.0670f,   68, 0},
    { 3034,    9.9317f,   69.6830f,   87, 0},
    { 3077,   10.0433f,   68.7330f,  100, 0},
    { 3115,   10.0858f,   -7.7170f,   91, 0},
    { 3147,   10.1167f,   73.4000f,  111, 0},
    { 3169,   10.2417f,    3.4670f,  112, 0},
    { 3184,   10.2558f,   41.4220f,  100, 0},
    { 3190,   10.2633f,   21.8330f,  118, 0},
    { 3193,   10.2658f,   21.8830f,  114, 0},
    { 3198,   10.2700f,   45.5500f,  109, 0},
    { 3227,   10.3283f,   19.8670f,  118, 0},
    { 3344,   10.7167f,   24.9170f,  100, 0},
    { 3351,   10.7317f,   11.7000f,   97, 0},
    { 3368,   10.7800f,   11.8170f,   97, 0},
    { 3379,   10.8000f,   12.5830f,   97, 0},
    { 3384,   10.8017f,   12.6330f,   99, 0},
    { 3389,   10.8058f,   12.5330f,  116, 0},
    { 3395,   10.8117f,   32.9830f,  124, 0},
    { 3521,   11.0883f,   -0.0360f,   90, 0},
    { 3556,   11.1917f,   55.6670f,  100, 0},
    { 3593,   11.2317f,   12.8170f,  115, 0},
    { 3621,   11.3008f,  -32.8080f,   90, 0},
    { 3623,   11.3150f,   13.0830f,   97, 0},
    { 3627,   11.3367f,   12.9830f,   89, 0},
    { 3628,   11.3383f,   13.5830f,  100, 0},
    { 3675,   11.4317f,   43.5830f,  107, 0},
    { 3726,   11.5050f,   47.0170f,  106, 0},
    { 3728,   11.5067f,   27.1330f,  124, 0},
    { 3810,   11.6400f,   11.4670f,  112, 0},
    { 3877,   11.7600f,   47.5000f,  113, 0},
    { 3893,   11.7858f,   48.7170f,  107, 0},
    { 3938,   11.8683f,   44.1170f,  103, 0},
    { 3953,   11.8908f,   52.3170f,  101, 0},
    { 3992,   11.9567f,   53.3830f,   99, 0},
    { 4026,   11.9708f,   50.9670f,  112, 0},
    { 4038,   12.0217f,  -18.8670f,  104, 0},
    { 4039,   12.0225f,  -18.8830f,  106, 0},
    { 4051,   12.0317f,   44.5330f,  117, 0},
    { 4111,   12.0750f,   43.0670f,  110, 0},
    { 4125,   12.0817f,   65.1670f,  100, 0},
    { 4143,   12.1033f,   42.5330f,  118, 0},
    { 4168,   12.1233f,   13.2000f,  122, 0},
    { 4192,   12.1392f,   14.9000f,  100, 0},
    { 4203,   12.1508f,   33.2000f,  116, 0},
    { 4216,   12.1583f,   13.1500f,   99, 0},
    { 4236,   12.2750f,   69.4670f,   97, 0},
    { 4244,   12.2917f,   37.8170f,   99, 0},
    { 4251,   12.3000f,   28.1670f,  118, 0},
    { 4258,   12.3167f,   47.3000f,   83, 0},
    { 4261,   12.3208f,    5.8170f,  111, 0},
    { 4274,   12.3350f,   29.6170f,  111, 0},
    { 4278,   12.3383f,   29.2830f,  110, 0},
    { 4303,   12.3583f,    4.4670f,   95, 0},
    { 4321,   12.3817f,   15.8170f,   93, 0},
    { 4339,   12.3967f,    6.0830f,  122, 0},
    { 4340,   12.3983f,   16.7170f,  122, 0},
    { 4350,   12.4033f,   16.6830f,  118, 0},
    { 4365,   12.4150f,    7.3170f,   97, 0},
    { 4374,   12.4183f,   12.8830f,   93, 0},
    { 4382,   12.4250f,   18.1830f,   90, 0},
    { 4387,   12.4267f,   12.8170f,  124, 0},
    { 4394,   12.4317f,   18.2170f,  118, 0},
    { 4406,   12.4350f,   12.9500f,   89, 0},
    { 4414,   12.4383f,   31.2170f,  100, 0},
    { 4419,   12.4408f,   15.0500f,  118, 0},
    { 4429,   12.4467f,   11.1000f,  107, 0},
    { 4435,   12.4483f,   13.0830f,  107, 0},
    { 4438,   12.4483f,   13.0000f,  105, 0},
    { 4450,   12.4567f,   17.0830f,  105, 0},
    { 4459,   12.4600f,   13.9830f,  110, 0},
    { 4461,   12.4617f,   13.1830f,  118, 0},
    { 4472,   12.4967f,    8.0000f,   83, 0},
    { 4473,   12.4983f,   13.4330f,  110, 0},
    { 4477,   12.5017f,   13.6330f,  112, 0},
    { 4478,   12.5025f,   12.3330f,  120, 0},
    { 4486,   12.5133f,   12.4000f,   87, 0},
    { 4494,   12.5150f,   25.7670f,  102, 0},
    { 4501,   12.5217f,   14.4170f,   95, 0},
    { 4503,   12.5225f,   11.1670f,  118, 0},
    { 4526,   12.5408f,    7.7000f,   99, 0},
    { 4527,   12.5408f,    2.6500f,  107, 0},
    { 4535,   12.5483f,    8.2000f,   99, 0},
    { 4536,   12.5492f,    2.1830f,  107, 0},
    { 4546,   12.5567f,   -3.7830f,  107, 0},
    { 4548,   12.5600f,   14.5000f,  103, 0},
    { 4552,   12.5633f,   12.5500f,   97, 0},
    { 4559,   12.5700f,   27.9670f,   99, 0},
    { 4564,   12.5742f,   11.4330f,  118, 0},
    { 4565,   12.5775f,   25.9830f,   99, 0},
    { 4569,   12.5800f,   13.1500f,   93, 0},
    { 4571,   12.5825f,   14.2170f,  119, 0},
    { 4579,   12.5892f,   11.8170f,   97, 0},
    { 4594,   12.6667f,  -11.6170f,   80, 0},
    { 4596,   12.6683f,   10.1670f,  119, 0},
    { 4605,   12.6833f,   61.6170f,  103, 0},
    { 4621,   12.7008f,   11.6500f,   95, 0},
    { 4636,   12.7225f,    2.6830f,   97, 0},
    { 4638,   12.7233f,   11.4330f,  118, 0},
    { 4647,   12.7308f,   11.5830f,  122, 0},
    { 4649,   12.7317f,   11.5500f,   88, 0},
    { 4651,   12.7342f,   16.3830f,  110, 0},
    { 4660,   12.7433f,   11.2000f,  118, 0},
    { 4689,   12.7667f,   13.7670f,  117, 0},
    { 4697,   12.7817f,   -5.8000f,   99, 0},
    { 4699,   12.7842f,   -8.6580f,  103, 0},
    { 4710,   12.8000f,   15.1670f,  122, 0},
    { 4725,   12.8350f,   25.5000f,   99, 0},
    { 4736,   12.8483f,   41.1170f,   83, 0},
    { 4753,   12.8717f,   -1.5330f,  103, 0},
    { 4754,   12.8733f,   11.3170f,  118, 0},
    { 4762,   12.8892f,   11.2330f,  107, 0},
    { 4781,   12.9133f,  -10.5330f,  114, 0},
    { 4800,   12.9400f,   46.3170f,  124, 0},
    { 4826,   12.9567f,   21.6830f,   86, 0},
    { 4856,   12.9983f,  -15.0330f,  112, 0},
    { 4866,   12.9983f,   14.1830f,  122, 0},
    { 4900,   13.0300f,    2.5000f,  118, 0},
    { 4945,   13.0917f,  -49.4670f,   85, 0},
    { 4976,   13.1317f,   -6.9830f,  110, 0},
    { 5005,   13.1817f,   37.0500f,   97, 0},
    { 5033,   13.2283f,   36.5830f,   99, 0},
    { 5055,   13.2633f,   42.0330f,   88, 0},
    { 5068,   13.2983f,  -21.0330f,  103, 0},
    { 5084,   13.3208f,  -21.8170f,  117, 0},
    { 5128,   13.4258f,  -43.0170f,   70, 0},
    { 5170,   13.4742f,  -17.9670f,  118, 0},
    { 5194,   13.4983f,   47.1950f,   83, 0},
    { 5195,   13.5000f,   47.2670f,   97, 0},
    { 5236,   13.6167f,  -29.8670f,   77, 0},
    { 5253,   13.6800f,  -31.6330f,   99, 0},
    { 5457,   14.0533f,   54.3500f,   77, 0},
    { 5474,   14.0975f,   53.6670f,  109, 0},
    { 5506,   14.2142f,   -3.2170f,  118, 0},
    { 5746,   14.7650f,    1.9500f,  115, 0},
    { 5775,   14.8783f,    3.5500f,  121, 0},
    { 5850,   15.1208f,    1.5330f,  113, 0},
    { 5866,   15.1108f,   55.7670f,  100, 0},
    { 5907,   15.2592f,   56.3170f,  107, 0},
    { 6300,   17.2967f,  -62.8170f,   95, 0},
    { 6503,   17.9017f,   70.1500f,   99, 0},
    { 6744,   19.1600f,  -63.8500f,   88, 0},
    { 6822,   19.7475f,  -14.8000f,   90, 0},
    { 6946,   20.5342f,   60.1530f,   89, 0},
    { 7331,   22.6175f,   34.4170f,   93, 0},
    { 7339,   22.6292f,   23.7830f,  121, 0},
    { 7479,   23.0817f,   12.3170f,  113, 0},
    { 7552,   23.2017f,  -42.5830f,  102, 0},
    { 7582,   23.2967f,  -42.3670f,  102, 0},
    { 7590,   23.3108f,  -42.2330f,  115, 0},
    { 7599,   23.3200f,  -42.2500f,  116, 0},
    { 7619,   23.3358f,    8.2000f,  118, 0},
    { 7723,   23.5892f,  -12.9500f,  121, 0},
    { 7742,   23.6008f,   10.7670f,  121, 0},
    { 7793,   23.9667f,  -32.5830f,   90, 0},
    {  129,    0.4808f,   60.2170f,   69, 1},
    {  188,    0.6642f,   85.3330f,   87, 1},
    {  225,    0.7125f,   61.7830f,   73, 1},
    {  366,    1.0750f,   62.3170f,   97, 1},
    {  457,    1.3192f,   58.2830f,   63, 1},
    {  559,    1.4708f,   63.3000f,   97, 1},
    {  581,    1.5317f,   60.6670f,   72, 1},
    {  663,    1.7700f,   61.2500f,   72, 1},
    {  752,    1.9583f,   37.7830f,   57, 1},
    {  869,    2.3192f,   57.1330f,   40, 1},
    {  884,    2.3758f,   57.1330f,   40, 1},
    { 1039,    2.7075f,   42.7830f,   51, 1},
    { 1342,    3.4867f,   37.3830f,   67, 1},
    { 1502,    4.0975f,   62.3330f,   56, 1},
    { 1528,    4.1492f,   51.2170f,   62, 1},
    { 1545,    4.2167f,   50.2330f,   67, 1},
    { 1647,    4.5967f,   19.1170f,   62, 1},
    { 1662,    4.6742f,   10.9330f,   62, 1},
    { 1750,    5.0408f,   23.6670f,   72, 1},
    { 1807,    5.1175f,   16.4670f,   72, 1},
    { 1817,    5.1325f,   16.6830f,   72, 1},
    { 1857,    5.2375f,   39.3330f,   72, 1},
    { 1893,    5.2292f,   33.4500f,   73, 1},
    { 1907,    5.4658f,   35.3330f,   72, 1},
    { 1912,    5.4783f,   35.8330f,   67, 1},
    { 1960,    5.6017f,   34.1330f,   60, 1},
    { 2099,    5.8733f,   32.5500f,   56, 1},
    { 2129,    6.0350f,   23.3000f,   67, 1},
    { 2168,    6.1483f,   24.3330f,   52, 1},
    { 2169,    6.1050f,   13.9500f,   57, 1},
    { 2175,    6.1150f,   20.3330f,   72, 1},
    { 2194,    6.1667f,   12.8000f,   82, 1},
    { 2232,    6.4483f,   -4.7500f,   37, 1},
    { 2244,    6.5308f,    4.9500f,   47, 1},
    { 2251,    6.5375f,   28.3330f,   67, 1},
    { 2264,    6.6908f,    9.8830f,   38, 1},
    { 2301,    6.8125f,    0.4670f,   60, 1},
    { 2323,    7.0367f,   -8.3500f,   55, 1},
    { 2343,    7.0825f,  -10.6170f,   67, 1},
    { 2353,    7.1075f,  -10.2670f,   72, 1},
    { 2360,    7.1108f,  -15.6170f,   72, 1},
    { 2362,    7.1183f,  -24.9500f,   33, 1},
    { 2374,    7.1583f,   13.1330f,   72, 1},
    { 2392,    7.4875f,   20.9170f,  100, 4},
    { 2395,    7.4742f,   13.5330f,   82, 1},
    { 2420,    7.6383f,   21.5670f,   85, 1},
    { 2422,    7.6958f,  -14.4830f,   43, 1},
    { 2423,    7.7000f,  -13.8670f,   67, 1},
    { 2437,    7.7000f,  -14.8170f,   60, 1},
    { 2447,    7.7433f,  -23.8500f,   60, 1},
    { 2451,    7.7950f,  -37.9670f,   27, 1},
    { 2477,    7.8725f,  -38.5330f,   57, 1},
    { 2516,    7.9742f,  -60.8670f,   33, 1},
    { 2539,    8.1083f,  -12.8170f,   67, 1},
    { 2547,    8.1292f,  -49.1830f,   49, 1},
    { 2548,    8.2300f,   -5.7170f,   55, 1},
    { 2571,    8.2933f,  -29.7330f,   72, 1},
    { 2627,    8.6258f,  -29.9500f,   82, 1},
    { 2632,    8.6717f,   19.9830f,   33, 1},
    { 2655,    8.7758f,   78.2170f,  112, 1},
    { 2660,    8.7942f,  -47.2000f,   87, 1},
    { 2669,    8.7575f,  -52.9500f,   69, 1},
    { 2682,    8.8542f,   11.8000f,   68, 1},
    { 2808,    9.1992f,  -64.8670f,   62, 2},
    { 3114,   10.0283f,  -60.1170f,   43, 1},
    { 3228,   10.3308f,  -51.7170f,   62, 1},
    { 3293,   10.5942f,  -58.2330f,   43, 1},
    { 3330,   10.6742f,  -54.1330f,   72, 1},
    { 3532,   11.1025f,  -58.6670f,   30, 1},
    { 3603,   11.1708f,  -61.2500f,   90, 1},
    { 3766,   11.6025f,  -61.6170f,   50, 1},
    { 4103,   12.0792f,  -61.2500f,   72, 1},
    { 4349,   12.3983f,  -61.8830f,   72, 1},
    { 4463,   12.4742f,  -64.8000f,   82, 1},
    { 4609,   12.7158f,  -62.9830f,   72, 1},
    { 4755,   12.8983f,  -60.3500f,   40, 1},
    { 5281,   13.7508f,  -62.9000f,   57, 1},
    { 5316,   13.8758f,  -61.8670f,   62, 1},
    { 5460,   14.1267f,  -48.3330f,   57, 1},
    { 5617,   14.4975f,  -60.7170f,   57, 1},
    { 5662,   14.5975f,  -56.5500f,   57, 1},
    { 5822,   15.0733f,  -54.3670f,   57, 1},
    { 5927,   15.4342f,  -50.6670f,   80, 2},
    { 6025,   16.0600f,  -60.4330f,   57, 1},
    { 6067,   16.1317f,  -54.2170f,   57, 1},
    { 6087,   16.1833f,  -57.9170f,   57, 1},
    { 6124,   16.4175f,  -40.6670f,   57, 1},
    { 6193,   16.6875f,  -48.7670f,   53, 1},
    { 6200,   16.7383f,  -47.4670f,   72, 1},
    { 6204,   16.7583f,  -47.0170f,   82, 1},
    { 6231,   16.9000f,  -41.8330f,   25, 1},
    { 6242,   16.9192f,  -39.4670f,   57, 1},
    { 6250,   16.9533f,  -45.9500f,   72, 1},
    { 6281,   17.0617f,  -37.9830f,   57, 1},
    { 6383,   17.5667f,  -32.5670f,   72, 1},
    { 6396,   17.5983f,  -35.0170f,   82, 1},
    { 6404,   17.6158f,  -33.2170f,   72, 1},
    { 6416,   17.6483f,  -32.3500f,   52, 1},
    { 6425,   17.6817f,  -31.5500f,   72, 1},
    { 6530,   18.0375f,  -24.3670f,   57, 1},
    { 6531,   18.0758f,  -22.5000f,   58, 1},
    { 6546,   18.1008f,  -23.3170f,   82, 1},
    { 6603,   18.2583f,  -18.4170f,   72, 1},
    { 6633,   18.4708f,    6.6000f,   47, 1},
    { 6645,   18.5108f,  -16.9000f,   72, 1},
    { 6664,   18.5617f,   -8.1830f,   72, 1},
    { 6694,   18.7542f,   -9.3830f,   80, 1},
    { 6716,   18.9250f,  -19.8830f,   72, 1},
    { 6755,   19.1233f,    4.2330f,   72, 1},
    { 6756,   19.1283f,    4.7000f,   72, 1},
    { 6802,   19.3067f,   20.2670f,   82, 1},
    { 6811,   19.3892f,   46.3830f,   67, 1},
    { 6819,   19.4133f,   40.1830f,   77, 1},
    { 6823,   19.7133f,   23.3000f,   72, 1},
    { 6830,   19.7183f,   23.1000f,   77, 1},
    { 6834,   19.7242f,   29.4000f,   77, 1},
    { 6866,   20.0667f,   44.1670f,   72, 1},
    { 6871,   20.0792f,   35.7670f,   57, 1},
    { 6882,   20.1792f,   26.4830f,   72, 1},
    { 6883,   20.1833f,   26.4830f,   82, 1},
    { 6910,   20.3525f,   40.7670f,   72, 1},
    { 6913,   20.3567f,   38.5000f,   67, 1},
    { 6939,   20.5333f,   60.6500f,   77, 1},
    { 6940,   20.5500f,   28.2830f,   67, 1},
    { 6991,   20.9167f,   47.4500f,   67, 1},
    { 7026,   21.0608f,   47.8170f,  107, 4},
    { 7039,   21.1717f,   45.6170f,   72, 1},
    { 7044,   21.1817f,   42.5000f,   82, 1},
    { 7062,   21.2342f,   46.3670f,   82, 1},
    { 7063,   21.2358f,   36.5000f,   72, 1},
    { 7082,   21.3533f,   47.1000f,   72, 1},
    { 7086,   21.3675f,   51.6000f,   82, 1},
    { 7092,   21.5317f,   48.4330f,   49, 1},
    { 7128,   21.7275f,   53.7170f,   82, 1},
    { 7160,   21.8933f,   62.6000f,   67, 1},
    { 7209,   22.0567f,   46.5000f,   72, 1},
    { 7235,   22.1817f,   57.2670f,   72, 1},
    { 7243,   22.2300f,   49.8830f,   67, 1},
    { 7296,   22.4317f,   52.3170f,   82, 1},
    { 7380,   22.7917f,   58.1170f,   72, 1},
    { 7419,   22.8883f,   60.8830f,   82, 1},
    { 7510,   23.1683f,   60.5670f,   72, 1},
    { 7654,   23.5650f,   61.5830f,   67, 1},
    { 7686,   23.5042f,   49.1330f,   72, 1},
    { 7789,   23.9383f,   56.7170f,   67, 1},
    { 7790,   23.9600f,   61.2000f,   82, 1},
    {  104,    0.4058f,  -72.0810f,   40, 2},
    {  362,    1.0533f,  -70.8500f,   62, 2},
    { 1261,    3.2033f,  -55.2170f,   83, 2},
    { 1851,    5.2350f,  -40.0500f,   72, 2},
    { 1904,    5.3242f,  -24.5170f,   77, 2},
    { 3201,   10.2958f,  -46.4170f,   68, 2},
    { 4147,   12.1008f,   18.5500f,  107, 2},
    { 4372,   12.4358f,  -72.6580f,   73, 2},
    { 4590,   12.5917f,  -26.7420f,   78, 2},
    { 4833,   12.9942f,  -70.8760f,   67, 2},
    { 5024,   13.2150f,   18.1670f,   76, 2},
    { 5053,   13.2683f,   17.7000f,   91, 2},
    { 5139,   13.4467f,  -47.4830f,   36, 2},
    { 5272,   13.7033f,   28.3830f,   62, 2},
    { 5286,   13.7700f,  -51.3670f,   72, 2},
    { 5466,   14.0567f,   28.5170f,   91, 2},
    { 5634,   14.4908f,   -5.9830f,   97, 2},
    { 5694,   14.6608f,  -26.5330f,  103, 2},
    { 5824,   15.0658f,  -33.0670f,   97, 2},
    { 5897,   15.2900f,  -21.0170f,   86, 2},
    { 5904,   15.3097f,    2.0830f,   65, 2},
    { 5946,   15.5617f,  -50.6500f,   97, 2},
    { 5986,   15.7742f,  -37.7860f,   77, 2},
    { 6093,   16.2850f,  -22.9670f,   72, 2},
    { 6101,   16.4258f,  -72.2000f,   92, 2},
    { 6121,   16.3933f,  -26.5250f,   56, 2},
    { 6139,   16.4617f,  -38.8500f,   91, 2},
    { 6144,   16.4692f,  -26.0250f,   91, 2},
    { 6171,   16.5417f,  -13.0500f,   82, 2},
    { 6205,   16.6950f,   36.4670f,   58, 2},
    { 6218,   16.7867f,   -1.9500f,   68, 2},
    { 6229,   16.8508f,   47.5330f,   91, 2},
    { 6235,   16.8950f,  -22.1670f,   86, 2},
    { 6254,   16.9517f,   -4.1000f,   66, 2},
    { 6266,   17.0200f,  -30.1170f,   68, 2},
    { 6273,   17.0433f,  -26.2670f,   70, 2},
    { 6284,   17.0458f,  -24.7670f,   86, 2},
    { 6287,   17.0533f,  -22.7000f,   91, 2},
    { 6293,   17.0983f,  -26.5830f,   83, 2},
    { 6304,   17.1475f,  -29.4670f,   83, 2},
    { 6316,   17.1808f,  -28.1330f,   86, 2},
    { 6325,   17.2017f,  -23.7670f,  100, 2},
    { 6333,   17.1900f,  -18.5170f,   78, 2},
    { 6341,   17.2850f,   43.1330f,   62, 2},
    { 6342,   17.2917f,  -19.5830f,   91, 2},
    { 6352,   17.4258f,  -48.4170f,   77, 2},
    { 6355,   17.4517f,  -26.3500f,   97, 2},
    { 6356,   17.4683f,  -17.8170f,   83, 2},
    { 6362,   17.5317f,  -67.0500f,   77, 2},
    { 6380,   17.5608f,  -39.0670f,   97, 2},
    { 6388,   17.5983f,  -44.7330f,   68, 2},
    { 6397,   17.6783f,  -53.6740f,   52, 2},
    { 6401,   17.6300f,  -23.9170f,   97, 2},
    { 6402,   17.6267f,   -3.2500f,   77, 2},
    { 6440,   17.8350f,  -20.3670f,   91, 2},
    { 6441,   17.8375f,  -37.0500f,   72, 2},
    { 6453,   17.8992f,  -34.6000f,  100, 2},
    { 6496,   17.9892f,  -44.2670f,   89, 2},
    { 6517,   18.0175f,   -8.9500f,   97, 2},
    { 6522,   18.0358f,  -30.0330f,   86, 2},
    { 6528,   18.0542f,  -30.0560f,   91, 2},
    { 6535,   18.0625f,   -0.3000f,  100, 2},
    { 6539,   18.0650f,   -7.5830f,   91, 2},
    { 6540,   18.0683f,  -27.7670f,  100, 2},
    { 6541,   18.0817f,  -43.7170f,   62, 2},
    { 6544,   18.1083f,  -24.9970f,   85, 2},
    { 6553,   18.0792f,  -25.9000f,   83, 2},
    { 6558,   18.1000f,  -21.9670f,   97, 2},
    { 6569,   18.1342f,  -31.8270f,   86, 2},
    { 6584,   18.1817f,  -52.2170f,   80, 2},
    { 6624,   18.5233f,  -30.3610f,   72, 2},
    { 6626,   18.4067f,  -24.8670f,   78, 2},
    { 6637,   18.5183f,  -32.3500f,   77, 2},
    { 6638,   18.5283f,  -25.5000f,   91, 2},
    { 6642,   18.5633f,  -23.4830f,   91, 2},
    { 6652,   18.5958f,  -32.9830f,   86, 2},
    { 6656,   18.6050f,  -23.9000f,   51, 2},
    { 6681,   18.7200f,  -32.3000f,   79, 2},
    { 6712,   18.8842f,   -8.7000f,   83, 2},
    { 6715,   18.9183f,  -30.4830f,   78, 2},
    { 6717,   18.9167f,  -22.7000f,   86, 2},
    { 6723,   18.9917f,  -36.6330f,   72, 2},
    { 6749,   19.1983f,    1.9000f,  100, 2},
    { 6752,   19.1808f,  -59.9830f,   53, 2},
    { 6760,   19.2317f,    1.0330f,   91, 2},
    { 6779,   19.2767f,   30.1830f,   84, 2},
    { 6809,   19.6667f,  -30.9670f,   70, 2},
    { 6838,   19.8967f,   18.7830f,   82, 2},
    { 6864,   20.0983f,  -21.9170f,   86, 2},
    { 6934,   20.5742f,    7.4000f,   86, 2},
    { 6981,   20.8900f,  -12.5330f,   91, 2},
    { 7006,   21.0150f,   16.1830f,  103, 2},
    { 7078,   21.4997f,   12.1670f,   62, 2},
    { 7089,   21.5575f,   -0.8230f,   63, 2},
    { 7099,   21.4083f,  -23.1830f,   72, 2},
    { 1499,    4.0550f,   36.3670f,   50, 3},
    { 1554,    4.2183f,   19.5330f,   90, 3},
    { 1555,    4.2233f,   19.5330f,   90, 3},
    { 1788,    5.0683f,   -3.3500f,   85, 3},
    { 1976,    5.5883f,   -5.3830f,   40, 3},
    { 1977,    5.5900f,   -4.8330f,   75, 3},
    { 1980,    5.5883f,   -5.9170f,   25, 3},
    { 1982,    5.5917f,   -5.2670f,   90, 3},
    { 2023,    5.6742f,   -2.1330f,   90, 3},
    { 2024,    5.6825f,   -1.9000f,   20, 3},
    { 2068,    5.7800f,    0.0830f,   80, 3},
    { 2237,    6.5292f,    4.9500f,   60, 3},
    { 2736,    9.0108f,  -45.9330f,   80, 3},
    { 3372,   10.7450f,  -59.8670f,   10, 3},
    { 6188,   16.5667f,  -48.7170f,   70, 3},
    { 6334,   17.2000f,  -35.9830f,   70, 3},
    { 6357,   17.4683f,  -34.2000f,   70, 3},
    { 6514,   18.0283f,  -23.0330f,   82, 3},
    { 6523,   18.0617f,  -24.3830f,   60, 3},
    { 6559,   18.1017f,  -24.1000f,   80, 3},
    { 6595,   18.2000f,  -19.6170f,   82, 3},
    { 6611,   18.3133f,  -13.8000f,   60, 1},
    { 6618,   18.3467f,  -16.1830f,   60, 3},
    { 6888,   20.2008f,   38.3500f,   70, 3},
    { 6960,   20.7358f,   30.7170f,   70, 3},
    { 6992,   20.9275f,   31.7170f,   70, 3},
    { 7000,   20.9867f,   44.3330f,   40, 3},
    {  246,    0.7908f,  -11.8750f,   81, 4},
    {  650,    1.7050f,   51.5670f,  101, 4},
    { 1360,    3.5217f,  -25.8670f,  100, 4},
    { 1535,    4.1975f,  -12.7330f,  102, 4},
    { 2438,    7.7008f,  -14.7170f,  107, 4},
    { 2440,    7.7183f,  -18.2000f,   99, 4},
    { 2610,    8.5675f,  -16.1500f,  114, 4},
    { 3132,   10.1275f,  -40.4330f,   87, 4},
    { 3195,   10.2658f,  -69.3330f,  110, 4},
    { 3242,   10.4067f,  -18.6330f,   86, 4},
    { 3587,   11.2467f,   55.0170f,   97, 4},
    { 3918,   11.7983f,  -57.1170f,   84, 4},
    { 4361,   12.2408f,  -18.7830f,  107, 4},
    { 5189,   13.5292f,  -65.9670f,   98, 4},
    { 5307,   13.8692f,  -51.0170f,  116, 4},
    { 5882,   15.3983f,   -9.7670f,  105, 4},
    { 6026,   16.0700f,  -34.0670f,  120, 4},
    { 6309,   17.1633f,   -0.9170f,  114, 4},
    { 6337,   17.2567f,  -38.4830f,  116, 4},
    { 6369,   17.4950f,  -23.7500f,  108, 4},
    { 6445,   17.8333f,  -20.0000f,  113, 4},
    { 6543,   17.9775f,   66.6330f,   88, 4},
    { 6563,   18.1133f,  -33.8670f,  116, 4},
    { 6572,   18.2008f,    6.8500f,   89, 4},
    { 6629,   18.4458f,  -23.1830f,  108, 4},
    { 6720,   18.8933f,   33.0280f,   89, 4},
    { 6741,   19.0283f,   -0.4000f,  115, 4},
    { 6751,   19.1300f,    6.0000f,  119, 4},
    { 6781,   19.6342f,   -6.5330f,  111, 4},
    { 6790,   19.7000f,   -1.5170f,  103, 4},
    { 6803,   19.3067f,   -2.7000f,  114, 4},
    { 6804,   19.3283f,   -9.1830f,  118, 4},
    { 6818,   19.7983f,  -14.0830f,   97, 4},
    { 6826,   19.7483f,   50.5330f,   89, 4},
    { 6853,   19.9933f,   22.7170f,   74, 4},
    { 7009,   21.0692f,  -11.3670f,   80, 4},
    { 7027,   21.0708f,   42.2330f,   89, 4},
    { 7293,   22.4942f,  -20.8330f,   72, 4},
    { 7662,   23.4375f,   42.5500f,   87, 4},
};
const uint16_t NGC_COUNT = 521;

// ---------- IC 45 objets ----------
const DeepSkyObject catalogIC[] PROGMEM = {
    {  289,    0.9225f,   61.0830f,  124, 4},
    {  342,    3.7750f,   68.1000f,   90, 0},
    {  356,    3.9500f,   69.3670f,  110, 0},
    {  405,    5.2675f,   34.2670f,   60, 3},
    {  410,    5.2817f,   33.4170f,   60, 3},
    {  418,    5.7542f,  -12.7000f,   90, 4},
    {  434,    5.6792f,   -2.4500f,   50, 3},
    {  443,    6.1708f,   22.5000f,   60, 3},
    { 2118,    5.0633f,   -7.8330f,   30, 3},
    { 2177,    7.0217f,   -9.9000f,   60, 3},
    { 2391,    8.6700f,  -52.9170f,   27, 1},
    { 2395,    7.7492f,  -31.9500f,   45, 1},
    { 2488,    7.9483f,  -56.9830f,   73, 1},
    { 2602,   10.7175f,  -64.4000f,   19, 1},
    { 2944,   11.6258f,  -63.0170f,   45, 1},
    { 3568,   11.1067f,  -35.0170f,  112, 4},
    { 4296,   12.2058f,   75.6670f,  120, 0},
    { 4325,   12.2500f,   -0.0170f,  120, 0},
    { 4406,   12.4350f,   12.9500f,   89, 0},
    { 4499,   12.5433f,   44.1670f,  122, 0},
    { 4617,   12.7150f,  -22.9670f,  116, 0},
    { 4665,   17.7700f,    5.6330f,   57, 1},
    { 4756,   18.6533f,    5.4330f,   50, 1},
    { 5070,   20.9267f,   44.3670f,   60, 3},
    { 5146,   21.8908f,   47.2670f,   79, 1},
    { 5217,   22.5050f,   50.9330f,  124, 4},
    { 1274,   18.1467f,  -23.6500f,   99, 3},
    { 1295,   18.5475f,   -8.8330f,  122, 4},
    { 1318,   20.2050f,   40.4330f,   60, 3},
    { 1396,   21.6292f,   57.5000f,   39, 3},
    { 1805,    2.5433f,   61.4500f,   60, 1},
    { 1848,    2.8508f,   60.4330f,   60, 1},
    { 4599,   12.7058f,  -16.8170f,  116, 0},
    { 4700,   12.8583f,  -11.3830f,  116, 0},
    { 4710,   12.8317f,   12.1670f,  113, 0},
    { 4889,   13.0008f,   27.9830f,  119, 0},
    { 3583,   11.2050f,   48.2170f,  120, 0},
    {  239,    0.7975f,   32.7170f,  120, 0},
    { 4182,   12.1292f,   10.3830f,  121, 0},
    { 3311,   10.6167f,  -27.5330f,  118, 0},
    { 3312,   10.6183f,  -27.5500f,  120, 0},
    { 4857,   12.9842f,   15.4500f,  125, 0},
    { 4111,   12.0750f,   43.0670f,  110, 0},
    { 4350,   12.4033f,   16.6830f,  118, 0},
    { 4221,   12.1950f,   65.0500f,  122, 0},
};
const uint16_t IC_COUNT = 45;

// ---------- PK 50 objets ----------
const DeepSkyObject catalogPK[] PROGMEM = {
    {    1,   17.9775f,   66.6330f,   88, 4},
    {    2,   10.4067f,  -18.6330f,   86, 4},
    {    3,   21.0692f,  -11.3670f,   80, 4},
    {    4,   22.4942f,  -20.8330f,   72, 4},
    {    5,   19.9933f,   22.7170f,   74, 4},
    {    6,   18.8933f,   33.0280f,   89, 4},
    {    7,   19.7483f,   50.5330f,   89, 4},
    {    8,    5.7542f,  -12.7000f,   90, 4},
    {    9,    7.4875f,   20.9170f,  100, 4},
    {   10,    1.7050f,   51.5670f,  101, 4},
    {   11,   11.2467f,   55.0170f,   97, 4},
    {   12,   19.7983f,  -14.0830f,   97, 4},
    {   13,   15.3983f,   -9.7670f,  105, 4},
    {   14,   17.1633f,   -0.9170f,  114, 4},
    {   15,   18.1233f,   13.7830f,   90, 4},
    {   16,   10.1275f,  -40.4330f,   87, 4},
    {   17,   17.2567f,  -29.4830f,  112, 4},
    {   18,   18.2258f,  -13.3670f,  108, 4},
    {   19,    0.9225f,   61.0830f,  124, 4},
    {   20,    6.5308f,    5.9000f,  115, 4},
    {   21,    0.7908f,  -11.8750f,   81, 4},
    {   22,   14.5508f,   23.8170f,  127, 4},
    {   23,   18.4458f,  -23.1830f,  108, 4},
    {   24,   23.2342f,   42.5330f,  108, 4},
    {   25,   21.0608f,   47.8170f,  107, 4},
    {   26,   21.0708f,   42.2330f,   89, 4},
    {   27,   18.5475f,   -8.8330f,  122, 4},
    {   28,   19.6342f,   -6.5330f,  111, 4},
    {   29,   13.5292f,  -65.9670f,   98, 4},
    {   30,    4.1975f,  -12.7330f,  102, 4},
    {   31,   13.8692f,  -51.0170f,  116, 4},
    {   32,   11.7983f,  -57.1170f,   84, 4},
    {   33,    9.2017f,  -48.2330f,  100, 4},
    {   34,    7.7008f,  -14.7170f,  107, 4},
    {   35,    7.7183f,  -18.2000f,   99, 4},
    {   36,   17.4950f,  -23.7500f,  108, 4},
    {   37,   19.3067f,   -2.7000f,  114, 4},
    {   38,   19.3283f,   -9.1830f,  118, 4},
    {   39,   17.8333f,  -20.0000f,  113, 4},
    {   40,   18.0125f,  -34.0670f,  120, 4},
    {   41,   18.0683f,  -27.7670f,  100, 4},
    {   42,   17.4258f,  -34.0670f,  120, 4},
    {   43,   16.0700f,  -34.0670f,  120, 4},
    {   44,   12.2408f,  -18.7830f,  107, 4},
    {   45,   11.1067f,  -35.0170f,  112, 4},
    {   46,    3.5217f,  -25.8670f,  100, 4},
    {   47,    8.5675f,  -16.1500f,  114, 4},
    {   48,   19.0283f,   -0.4000f,  115, 4},
    {   49,   19.1300f,    6.0000f,  119, 4},
    {   50,   19.7000f,   -1.5170f,  103, 4},
};
const uint16_t PK_COUNT = 50;

// ---------- Caldwell 109 objets ----------
const DeepSkyObject catalogCaldwell[] PROGMEM = {
    {    1,   22.0167f,   57.9830f,   79, 1},
    {    2,    0.7658f,   85.3330f,  109, 0},
    {    3,    0.4458f,   61.2170f,  108, 4},
    {    4,   21.7008f,   52.4830f,  103, 0},
    {    5,    0.9225f,   61.0830f,  108, 4},
    {    6,   17.9775f,   66.6330f,  108, 4},
    {    7,   23.3458f,   61.5830f,   72, 1},
    {    8,   23.4017f,   63.5830f,  107, 0},
    {    9,    2.8592f,   60.4330f,  113, 3},
    {   10,    1.3192f,   58.2830f,   63, 1},
    {   11,   23.3458f,   61.5830f,  107, 3},
    {   12,   20.5342f,   60.1500f,   89, 0},
    {   13,    1.4708f,   63.3000f,   97, 1},
    {   14,    2.3742f,   57.1330f,   40, 1},
    {   15,    4.0550f,   36.3670f,  112, 3},
    {   16,    7.9742f,  -60.8670f,   33, 1},
    {   17,    6.5308f,    4.9500f,   63, 3},
    {   18,    9.5217f,   21.5000f,   89, 0},
    {   19,   13.6167f,  -29.8670f,   77, 0},
    {   20,   12.3592f,   29.9170f,  107, 0},
    {   21,   13.4258f,  -43.0170f,   70, 0},
    {   22,   13.4467f,  -47.4830f,   36, 2},
    {   23,   14.4700f,  -56.0830f,   85, 1},
    {   24,   15.6150f,  -45.1170f,   57, 1},
    {   25,   16.0617f,  -60.4330f,   57, 1},
    {   26,   16.6875f,  -48.7670f,   53, 1},
    {   27,   17.1317f,  -45.8670f,   57, 1},
    {   28,   17.5317f,  -34.1330f,   57, 1},
    {   29,   18.0375f,  -24.3670f,   57, 1},
    {   30,   18.3258f,  -33.9670f,   53, 2},
    {   31,   19.1808f,  -59.9830f,   53, 2},
    {   32,   21.5317f,  -48.9670f,   36, 2},
    {   33,   10.7450f,  -59.8670f,   10, 3},
    {   34,   10.7250f,  -64.4000f,   19, 1},
    {   35,   10.6483f,  -62.4170f,   60, 1},
    {   36,    7.9483f,  -60.8670f,   33, 1},
    {   37,    8.6700f,  -52.9170f,   27, 1},
    {   38,    9.6967f,  -65.4500f,   57, 1},
    {   39,    6.5642f,  -52.6830f,   79, 4},
    {   40,    6.1617f,  -47.1170f,   53, 1},
    {   41,    8.1292f,  -49.1830f,   49, 1},
    {   42,    7.7950f,  -37.9670f,   27, 1},
    {   43,    7.8725f,  -38.5330f,   57, 1},
    {   44,    7.6958f,  -14.4830f,   43, 1},
    {   45,    6.7667f,  -20.7330f,   44, 1},
    {   46,    7.4108f,  -24.9500f,   57, 1},
    {   47,    7.0217f,   -9.9000f,   60, 3},
    {   48,    3.7742f,   24.1170f,   12, 1},
    {   49,    0.4058f,  -72.0810f,   40, 2},
    {   50,    0.8658f,  -72.8000f,   22, 0},
    {   51,    1.0533f,  -70.8500f,   62, 2},
    {   52,    3.3792f,  -37.2170f,   89, 0},
    {   53,    3.5558f,  -36.1330f,   97, 0},
    {   54,    3.6417f,  -35.4500f,   97, 0},
    {   55,    0.7925f,  -25.2880f,   72, 0},
    {   56,    1.5642f,   30.6600f,   59, 0},
    {   57,    4.1975f,  -12.7330f,  102, 4},
    {   58,    5.6825f,   -1.9000f,   20, 3},
    {   59,    5.1975f,   12.9830f,   50, 3},
    {   60,    5.2433f,   34.2670f,   60, 3},
    {   61,    5.5883f,   -5.3830f,   40, 3},
    {   62,   19.1808f,  -59.9830f,   53, 2},
    {   63,   19.6667f,  -30.9670f,   70, 2},
    {   64,   21.6733f,  -23.1830f,   72, 2},
    {   65,   18.9183f,  -30.4830f,   78, 2},
    {   66,   18.5233f,  -32.3500f,   77, 2},
    {   67,   18.7200f,  -32.3000f,   79, 2},
    {   68,   22.9483f,  -28.8500f,  103, 0},
    {   69,    7.0483f,   -8.3670f,   56, 1},
    {   70,    7.6100f,  -14.5000f,   43, 1},
    {   71,    6.1483f,   24.3330f,   52, 1},
    {   72,    5.8733f,   32.5500f,   56, 1},
    {   73,    5.6017f,   34.1330f,   60, 1},
    {   74,    5.4783f,   35.8330f,   67, 1},
    {   75,    2.7017f,   42.7830f,   51, 1},
    {   76,    1.3192f,   58.2830f,   63, 1},
    {   77,   23.4017f,   61.5830f,   72, 1},
    {   78,   23.9383f,   56.7170f,   67, 1},
    {   79,    1.5533f,   60.6500f,   71, 1},
    {   80,   21.5317f,   48.4330f,   49, 1},
    {   81,   19.8967f,   18.7830f,   82, 2},
    {   82,   20.8900f,  -12.5330f,   91, 2},
    {   83,   17.6267f,   -3.2500f,   77, 2},
    {   84,   16.5417f,  -13.0500f,   82, 2},
    {   85,   16.7867f,   -1.9500f,   68, 2},
    {   86,   16.9517f,   -4.1000f,   66, 2},
    {   87,   17.2850f,   43.1330f,   62, 2},
    {   88,   21.4997f,   12.1670f,   62, 2},
    {   89,   13.2150f,   18.1670f,   76, 2},
    {   90,   17.0200f,  -30.1170f,   68, 2},
    {   91,   17.0433f,  -26.2670f,   70, 2},
    {   92,   16.2850f,  -22.9670f,   72, 2},
    {   93,   16.3933f,  -26.5250f,   56, 2},
    {   94,    5.4017f,  -24.5170f,   77, 2},
    {   95,   21.5575f,   -0.8230f,   63, 2},
    {   96,   13.7033f,   28.3830f,   62, 2},
    {   97,   15.3097f,    2.0830f,   65, 2},
    {   98,   16.6950f,   36.4670f,   58, 2},
    {   99,   17.2850f,   43.1330f,   62, 2},
    {  100,    0.4058f,  -72.0810f,   40, 2},
    {  101,    0.8658f,  -72.8000f,   22, 0},
    {  102,    1.0533f,  -70.8500f,   62, 2},
    {  103,    3.3792f,  -37.2170f,   89, 0},
    {  104,    3.5558f,  -36.1330f,   97, 0},
    {  105,    3.6417f,  -35.4500f,   97, 0},
    {  106,   13.4258f,  -43.0170f,   70, 0},
    {  107,   13.4467f,  -47.4830f,   36, 2},
    {  108,    9.0108f,  -45.9330f,   80, 3},
    {  109,   10.4250f,  -59.0830f,   57, 1},
};
const uint16_t CALDWELL_COUNT = 109;

// ---------- BSC 105 objets ----------
const StarObject catalogBSC[] PROGMEM = {
    {  677,    1.3791f,  -57.2370f,  -12, OBJ_STAR, "Achernar"},
    { 5056,   13.7923f,  -49.2200f,  -11, OBJ_STAR, "Toliman"},
    { 5459,   14.6636f,  -60.8350f,   -3, OBJ_STAR, "Rigil Kent"},
    { 7001,   18.6157f,   38.7810f,    0, OBJ_STAR, "Vega"},
    { 1708,    5.2423f,  -52.6950f,    4, OBJ_STAR, "Canopus"},
    { 2061,    5.5955f,  -11.2020f,    2, OBJ_STAR, "Rigel"},
    { 2099,    5.9195f,   44.9470f,   10, OBJ_STAR, "Capella"},
    { 2693,    7.6554f,   22.0030f,   10, OBJ_STAR, "Pollux"},
    { 2421,    6.7525f,  -16.7130f,   12, OBJ_STAR, "Sirius"},
    { 1457,    4.5989f,   16.5090f,   13, OBJ_STAR, "Aldebaran"},
    { 5191,   13.4232f,  -11.1610f,   10, OBJ_STAR, "Spica"},
    { 5793,   15.2345f,   -9.3830f,    0, OBJ_STAR, "Arcturus"},
    { 6134,   16.4905f,  -26.4320f,    6, OBJ_STAR, "Antares"},
    { 7557,   19.8458f,    8.8680f,    8, OBJ_STAR, "Altair"},
    { 4731,   12.4436f,  -63.0990f,   13, OBJ_STAR, "Mimosa"},
    { 4730,   12.4431f,  -63.0990f,    8, OBJ_STAR, "Acrux"},
    { 4763,   12.5194f,  -63.0990f,   16, OBJ_STAR, "Gacrux"},
    { 1713,    5.2422f,   45.9990f,    8, OBJ_STAR, "Capella"},
    {  424,    1.4280f,   60.7160f,   13, OBJ_STAR, "Schedar"},
    {  603,    1.9060f,   29.5750f,   20, OBJ_STAR, "Hamal"},
    { 1790,    5.4197f,   28.6070f,   16, OBJ_STAR, "Elnath"},
    { 2990,    7.8546f,   28.0260f,   14, OBJ_STAR, "Castor"},
    { 3165,    9.2500f,  -58.9660f,   19, OBJ_STAR, "Avior"},
    { 3307,   10.1397f,  -58.9660f,   19, OBJ_STAR, "Alsephina"},
    { 4534,   11.9308f,   53.6950f,   22, OBJ_STAR, "Alioth"},
    { 4662,   12.2573f,  -58.7490f,   16, OBJ_STAR, "Miaplacidus"},
    { 4905,   13.0325f,  -78.7090f,   19, OBJ_STAR, "Peacock"},
    { 5054,   13.6647f,   49.3130f,   14, OBJ_STAR, "Alkaid"},
    { 5854,   15.5806f,  -14.7890f,   22, OBJ_STAR, "Zuben"},
    { 6556,   17.5621f,   12.5600f,   20, OBJ_STAR, "Rasalhague"},
    { 6879,   18.3561f,  -26.2990f,   19, OBJ_STAR, "Kaus Aust."},
    { 7121,   18.9360f,   38.7840f,   18, OBJ_STAR, "Vega"},
    { 7796,   20.3906f,   40.2570f,   12, OBJ_STAR, "Deneb"},
    { 8728,   22.9608f,  -29.6220f,   18, OBJ_STAR, "Fomalhaut"},
    {   15,    0.1396f,   29.0910f,   22, OBJ_STAR, "Alpheratz"},
    {   21,    0.1530f,   59.1500f,   24, OBJ_STAR, "Caph"},
    {  168,    0.5548f,   63.6700f,   27, OBJ_STAR, "Ruchbah"},
    {  337,    1.0692f,  -71.9650f,   24, OBJ_STAR, "Ankaa"},
    {  472,    1.5330f,   41.4030f,   22, OBJ_STAR, "Mirach"},
    {  617,    1.9800f,  -40.3050f,   29, OBJ_STAR, "Acamar"},
    {  799,    2.4975f,   89.2640f,   22, OBJ_STAR, "Polaris"},
    {  907,    2.8575f,   55.8950f,   24, OBJ_STAR, "Mirphak"},
    { 1228,    3.9087f,   40.9570f,   28, OBJ_STAR, "Algol"},
    { 1231,    3.9158f,   40.9570f,   24, OBJ_STAR, "Almach"},
    { 1325,    4.2308f,   -3.3540f,   28, OBJ_STAR, "Rigel"},
    { 1409,    4.4258f,   15.9520f,   28, OBJ_STAR, "Ain"},
    { 1412,    4.4264f,   15.6220f,   28, OBJ_STAR, "Alcyone"},
    { 1791,    5.4217f,   28.6070f,   28, OBJ_STAR, "Elnath"},
    { 1820,    5.4780f,   -1.2020f,   26, OBJ_STAR, "Mintaka"},
    { 1852,    5.5336f,   -0.2990f,   23, OBJ_STAR, "Alnilam"},
    { 1862,    5.5543f,   -1.2020f,   22, OBJ_STAR, "Alnitak"},
    { 1903,    5.5953f,   -1.9440f,   24, OBJ_STAR, "Saiph"},
    { 1948,    5.6316f,   -1.9440f,   24, OBJ_STAR, "Trapeze"},
    { 2004,    5.7941f,    7.4070f,   20, OBJ_STAR, "Betelgeuse"},
    { 2294,    6.3758f,   22.5130f,   28, OBJ_STAR, "Alhena"},
    { 2890,    7.5770f,   31.8880f,   15, OBJ_STAR, "Alhena"},
    { 3734,   11.2513f,  -58.7490f,   19, OBJ_STAR, "Eta Car"},
    { 3748,   11.3023f,   20.5240f,   21, OBJ_STAR, "Denebola"},
    { 4057,   12.2694f,  -63.0990f,   20, OBJ_STAR, "Delta Cru"},
    { 4199,   12.5194f,  -57.1130f,   26, OBJ_STAR, "Muhlifain"},
    { 4540,   11.9978f,   14.5720f,   20, OBJ_STAR, "Cor Caroli"},
    { 4786,   12.6939f,  -48.9600f,   23, OBJ_STAR, "Menkent"},
    { 5019,   13.5991f,  -57.1130f,   23, OBJ_STAR, "Hadar"},
    { 5165,   13.6647f,  -53.4660f,   23, OBJ_STAR, "Theta Cen"},
    { 5469,   14.7062f,  -27.0960f,   23, OBJ_STAR, "Zubenelg."},
    { 5531,   14.8454f,   74.1560f,   26, OBJ_STAR, "Kocab"},
    { 5563,   14.9444f,   74.1560f,   22, OBJ_STAR, "Dubhe"},
    { 6212,   16.6179f,  -34.2930f,   24, OBJ_STAR, "Graffias"},
    { 6527,   17.5086f,  -37.1040f,   22, OBJ_STAR, "Shaula"},
    { 6553,   17.5621f,  -12.5600f,   20, OBJ_STAR, "Sabik"},
    { 6588,   17.6222f,  -42.9970f,   27, OBJ_STAR, "Lesath"},
    { 6714,   17.9473f,   51.4890f,   28, OBJ_STAR, "Etamin"},
    { 6746,   18.0097f,  -30.4240f,   28, OBJ_STAR, "Kaus Med."},
    { 6869,   18.3492f,  -26.2990f,   20, OBJ_STAR, "Kaus Aus."},
    { 7106,   18.9218f,   26.8690f,   28, OBJ_STAR, "Sheliak"},
    { 7525,   19.7705f,   10.6150f,   21, OBJ_STAR, "Tarazed"},
    { 7924,   20.6904f,   45.2800f,   21, OBJ_STAR, "Sadr"},
    { 8425,   22.0961f,   -6.7230f,   25, OBJ_STAR, "Sadalsuud"},
    { 8597,   22.4881f,  -30.8950f,   27, OBJ_STAR, "Sadalmelik"},
    { 8636,   22.5836f,  -28.4530f,   22, OBJ_STAR, "Sadalbari"},
    { 8775,   23.0629f,   28.0830f,   26, OBJ_STAR, "Algenib"},
    { 8832,   23.2108f,   14.2200f,   29, OBJ_STAR, "Markab"},
    {  188,    0.6425f,   56.5370f,   24, OBJ_STAR, "Shedar"},
    {  264,    0.8553f,  -14.5400f,   28, OBJ_STAR, "Difda"},
    {  526,    1.6279f,  -10.1820f,   29, OBJ_STAR, "Menkar"},
    { 1641,    4.8549f,    6.9610f,   29, OBJ_STAR, "Ain"},
    { 3982,   12.1372f,  -24.7280f,   26, OBJ_STAR, "Algorab"},
    { 4295,   11.0624f,   61.7510f,   26, OBJ_STAR, "Dubhe"},
    { 4301,   11.0624f,   56.3830f,   24, OBJ_STAR, "Merak"},
    { 4359,   11.1622f,   53.6950f,   24, OBJ_STAR, "Phecda"},
    { 4375,   11.0368f,   38.1930f,   29, OBJ_STAR, "Megrez"},
    { 4660,   12.2573f,   57.0330f,   27, OBJ_STAR, "Mizar"},
    { 6148,   16.5151f,  -26.4320f,   29, OBJ_STAR, "Graffias"},
    { 6175,   16.5992f,  -28.2160f,   26, OBJ_STAR, "Pi Sco"},
    { 6241,   16.8360f,  -34.2930f,   23, OBJ_STAR, "Dschubba"},
    { 6670,   17.7931f,  -37.1040f,   28, OBJ_STAR, "Lesath"},
    { 6876,   18.3561f,  -26.2990f,   20, OBJ_STAR, "Kaus Aus."},
    { 7028,   18.8228f,   33.3630f,   21, OBJ_STAR, "Sulafat"},
    { 7178,   19.2128f,   67.6610f,   24, OBJ_STAR, "Rastaban"},
    { 7570,   19.8617f,   21.6880f,   22, OBJ_STAR, "Azel"},
    { 7602,   19.9297f,  -21.0170f,   28, OBJ_STAR, "Nunki"},
    { 7950,   21.0959f,  -11.3720f,   28, OBJ_STAR, "Enif"},
    { 8308,   21.7959f,  -16.1320f,   28, OBJ_STAR, "Sadalsuud"},
    { 8414,   22.0634f,   -0.3190f,   28, OBJ_STAR, "Ancha"},
    { 8634,   22.5800f,   -0.3190f,   24, OBJ_STAR, "Skat"},
};
const uint16_t BSC_COUNT = 105;

// Accès catalogues - Teensy 4.1
DeepSkyObject getObjectFromCatalog(const DeepSkyObject* catalog, uint16_t index) {
    return catalog[index];
}
StarObject getStarFromCatalog(uint16_t index) {
    return catalogBSC[index];
}

// ============================================================
// SECTION 1 : CONFIGURATION
// ============================================================
// Adaptateur I2C de l'écran : 0x27 avec une puce PCF8574T, 0x3F avec une PCF8574AT (Freenove et
// d'autres livrent l'une ou l'autre). Au démarrage, l'écran prend celle qui répond.
#define LCD_ADDR      0x27
#define LCD_ADDR_ALT  0x3F
#define BTN_UP      6
#define BTN_DOWN    7
#define BTN_LEFT    8
#define BTN_RIGHT   9
#define BTN_ENTER  10

#define MEGA_BAUD         38400
#define POLL_INTERVAL_MS   250    
#define TEENSY_TIMEOUT_MS  500    
#define DEBOUNCE_MS         50
#define FAST_SCROLL_DELAY  150    
#define FAST_SCROLL_STEP    10    

// ============================================================
// SECTION 2 : OBJETS GLOBAUX
// ============================================================
LiquidCrystal_I2C lcd(LCD_ADDR, 20, 4);

// ============================================================
// SECTION 3 : ÉTAT MONTURE (mis à jour par polling)
// ============================================================
double  m_currentRA   = 0.0;
double  m_currentDEC  = 0.0;
double  m_currentAlt  = 0.0;
double  m_currentAz   = 0.0;
double  m_parkAlt     = 0.0;
double  m_parkAz      = 0.0;
String  trackedObjectName = "";
bool    m_isTracking  = false;
bool    m_isSlewing   = false;
bool    m_limitHit    = false;
bool    m_isParked    = false;
bool    m_isAligned   = false;
bool    m_timeSet     = true;     // sera update via Mega

double  m_slewSpeed   = 2.0;
bool    m_online      = false;
bool    m_isPaused    = false;
double  targetRA      = -1.0;
double  targetDEC     = -1.0;

uint8_t mountType = 0;
String global_gm = "";
float   gearRatioAZ = 750.0;
float   gearRatioALT = 750.0;
bool    buzzerOn = true;
bool    temp_isEnglish = true;
bool    gpsEnabled = true;
bool    temp_gpsEnabled = true;
bool    motorPowerOn = true;
bool    temp_motorPowerOn = true;

double  temp_slewSpeed = 2.0;
uint8_t temp_mountType = 0;
float   temp_gearRatioAZ = 750.0;
float   temp_gearRatioALT = 750.0;
bool    temp_buzzerOn = true;

void loadEEPROM() {
    if(EEPROM.read(0) == 42) {
        isEnglish = EEPROM.read(15) > 0;
        displayRaDec = EEPROM.read(16) > 0;
    } else {
        EEPROM.write(0, 42);
        EEPROM.write(15, isEnglish);
        EEPROM.write(16, displayRaDec);
    }
}

void saveEEPROM() {
    EEPROM.write(15, isEnglish);
    EEPROM.write(16, displayRaDec);
}

char           uiMsgL0[21] = "";
char           uiMsgL1[21] = "";
unsigned long  uiMsgUntil  = 0;
int            uiMsgReturn = 0;

// ============================================================
// SECTION 4 : ÉTATS UI
// ============================================================
enum UIState {
    UI_MAIN, UI_CAT_SELECT, UI_OBJECT_LIST, UI_OBJECT_INFO,
    UI_SLEWING, UI_SETTINGS, UI_SPEED, UI_ALIGN, UI_PARKING,
    UI_MOUNT, UI_RATIO_AZ, UI_RATIO_ALT, UI_BEEP, UI_OFFLINE,
    UI_MESSAGE, UI_EDIT_TIME, UI_EDIT_LOCATION, UI_MENU_SELECT,
    UI_MOTOR_POWER, UI_LANGUAGE, UI_ALIGN_CENTER, UI_GPS, UI_COORD_MODE,
    UI_CUSTOM_GOTO, UI_SPIRAL
};
UIState uiState = UI_MAIN;

float ratioStep = 1.0;

bool isAlignWorkflow = false;
bool isParkingWorkflow = false;

const char* const CAT_NAMES[] = { "Messier","NGC","IC","PK","Caldwell","Etoiles","SysSol  " };

CatID    currentCat  = CAT_MESSIER;
uint32_t objectIndex = 0;

DeepSkyObject selectedObj;
StarObject    selectedStar;
bool          selectedIsStar = false;

int  settingsSel = 0;
int  parkSel = 0;
int  menuSel = 0;
int  editSel = 0;
bool lcdNeedsRefresh = true;

// ============================================================
// SECTION 5 : BOUTONS
// ============================================================
const uint8_t BTN_PINS[5] = {BTN_UP,BTN_DOWN,BTN_LEFT,BTN_RIGHT,BTN_ENTER};
#define BTN_IDX_UP    0
#define BTN_IDX_DOWN  1
#define BTN_IDX_LEFT  2
#define BTN_IDX_RIGHT 3
#define BTN_IDX_ENTER 4

bool btnPressed[5]  = {};
bool btnWas[5]      = {};
bool btnState[5]    = {};
bool btnPrev[5]     = {};
unsigned long btnTime[5]     = {};
unsigned long btnHoldTime[5] = {};

// ============================================================
// SECTION 6 : CARACTÈRES LCD
// ============================================================
byte charArrowUp[8] = {0b00100,0b01110,0b10101,0b00100,0b00100,0b00100,0b00100,0b00000};
byte charArrowDn[8] = {0b00100,0b00100,0b00100,0b00100,0b10101,0b01110,0b00100,0b00000};
byte charStar[8]    = {0b00100,0b10101,0b01110,0b11111,0b01110,0b10101,0b00100,0b00000};
byte charGalaxy[8]  = {0b00000,0b01110,0b11011,0b10001,0b11011,0b01110,0b00000,0b00000};
byte charGlob[8]    = {0b01110,0b11111,0b11111,0b11111,0b11111,0b11111,0b01110,0b00000};
byte charNebula[8]  = {0b10001,0b01010,0b00100,0b11111,0b00100,0b01010,0b10001,0b00000};
byte charSpeed[8]   = {0b00001,0b00011,0b00111,0b01111,0b00111,0b00011,0b00001,0b00000};
byte charCheck[8]   = {0b00000,0b00001,0b00011,0b10110,0b11100,0b01000,0b00000,0b00000};

#define CHAR_UP     0
#define CHAR_DOWN   1
#define CHAR_STAR   2
#define CHAR_GALAXY 3
#define CHAR_GLOB   4
#define CHAR_NEBULA 5
#define CHAR_SPEED  6
#define CHAR_CHECK  7

void initCustomChars(){
    lcd.createChar(CHAR_UP,    charArrowUp);
    lcd.createChar(CHAR_DOWN,  charArrowDn);
    lcd.createChar(CHAR_STAR,  charStar);
    lcd.createChar(CHAR_GALAXY,charGalaxy);
    lcd.createChar(CHAR_GLOB,  charGlob);
    lcd.createChar(CHAR_NEBULA,charNebula);
    lcd.createChar(CHAR_SPEED, charSpeed);
    lcd.createChar(CHAR_CHECK, charCheck);
}

uint8_t getTypeChar(uint8_t t){
    switch(t){
        case OBJ_GALAXY:       return CHAR_GALAXY;
        case OBJ_OPEN_CLUSTER: return CHAR_STAR;
        case OBJ_GLOB_CLUSTER: return CHAR_GLOB;
        case OBJ_STAR:         return CHAR_STAR;
        default:               return CHAR_NEBULA;
    }
}

// ============================================================
// SECTION 7 : COMMUNICATION
// ============================================================
String mega_cmd(const String &cmd, bool needsReply=true){
    while(Serial1.available()) Serial1.read(); // Flush out-of-sync data
    Serial1.print(cmd);
    Serial1.print('#');
    if(!needsReply) return "";
    
    char resp_buf[128];
    int resp_len = 0;
    
    unsigned long t0=millis();
    while(millis()-t0 < TEENSY_TIMEOUT_MS){
        readButtons(); // Keep scanning buttons while waiting!
        while(Serial1.available()){
            char c=(char)Serial1.read();
            if(c=='#') {
                resp_buf[resp_len] = '\0';
                return String(resp_buf);
            }
            if (resp_len < 127) {
                resp_buf[resp_len++] = c;
            }
            // :SC repond "1" seul depuis le 2026-11-17 (comme OnStep) ; une ancienne
            // monture ajoute "Updating#...#", vide au debut de la commande suivante.
            if (cmd.startsWith(":S") && !cmd.startsWith(":SL") && !cmd.startsWith(":SG") && resp_len == 1) {
                if (resp_buf[0] == '0' || resp_buf[0] == '1') {
                    resp_buf[resp_len] = '\0';
                    return String(resp_buf);
                }
            }
            if (cmd == ":MS" && resp_len == 1 && resp_buf[0] == '0') {
                resp_buf[resp_len] = '\0';
                return String(resp_buf);
            }
            if (cmd == ":Q" && resp_len == 1 && resp_buf[0] == '0') {
                resp_buf[resp_len] = '\0';
                return String(resp_buf);
            }
        }
    }
    resp_buf[resp_len] = '\0';
    return String(resp_buf); // Return whatever we received instead of ""!
}

String formatRA(double ra_h){
    char b[10];
    int h=(int)ra_h, m=(int)((ra_h-h)*60.0), s=(int)(((ra_h-h)*60.0-m)*60.0);
    sprintf(b,"%02d:%02d:%02d",h,m,s);
    return String(b);
}
String formatDEC(double dec_d){
    char b[12];
    bool neg=(dec_d<0); dec_d=fabs(dec_d);
    int d=(int)dec_d, m=(int)((dec_d-d)*60.0), s=(int)(((dec_d-d)*60.0-m)*60.0);
    sprintf(b,"%c%02d*%02d:%02d",neg?'-':'+',d,m,s);
    return String(b);
}
double parseRA(const String &s){
    if(s.length()<8) return 0.0;
    return s.substring(0,2).toInt()+s.substring(3,5).toInt()/60.0
          +s.substring(6,8).toInt()/3600.0;
}
double parseDEC_r(const String &s){
    if(s.length()<5) return 0.0;
    bool neg=(s.charAt(0)=='-');
    String t=s.substring(1); t.replace('*',':'); t.replace('\'',':');
    double v=t.substring(0,2).toInt()+t.substring(3,5).toInt()/60.0;
    if(t.length()>=8) v+=t.substring(6,8).toInt()/3600.0;
    return neg?-v:v;
}

void pollMega(){
    String resp=mega_cmd(":GBE");
    if(resp.length()<5){ m_online=false; return; }
    m_online=true;
    int idx=0;
    auto next=[&]()->String{
        int c=resp.indexOf(',',idx);
        String v=(c<0)?resp.substring(idx):resp.substring(idx,c);
        idx=(c<0)?(int)resp.length():c+1;
        return v;
    };
    m_isTracking=next().toInt();
    m_isSlewing =next().toInt();
    if (m_isSlewing) {
        String tra = mega_cmd(":Gr");
        String tdec = mega_cmd(":Gd");
        if (tra.length() >= 8) targetRA = parseRA(tra);
        if (tdec.length() >= 5) targetDEC = parseDEC_r(tdec);
    }
    m_limitHit  =next().toInt();
    m_slewSpeed =next().toInt()/10.0;
    m_currentAlt=next().toFloat();
    m_currentAz =next().toFloat();
    m_isParked  =next().toInt();
    m_isAligned =next().toInt();

    String gu = mega_cmd(":GU");
    if(gu.length() > 0) {
        // Heure non reglee = '?' depuis le firmware monture v9.3 ('F' avant, qui veut
        // dire "parking echoue" chez OnStep) : la raquette la croyait toujours reglee.
        m_timeSet = (gu.indexOf('?') < 0);
    }

    String ra=mega_cmd(":GR"), dec=mega_cmd(":GD");
    if(ra.length() >=8) m_currentRA =parseRA(ra);
    if(dec.length()>=5) m_currentDEC=parseDEC_r(dec);
    
    String gm = mega_cmd(":GM");
    global_gm = gm;
    if (gm.startsWith("AltAz")) mountType = 0;
    else if (gm.startsWith("ForkEq")) mountType = 1;
    else if (gm.startsWith("GermanEq")) mountType = 2;
}

// ============================================================
// SECTION 8 : COMMANDES VERS MEGA
// ============================================================
// Precession IAU 1976 : J2000 -> equinoxe de la date de la raquette. Les catalogues de la
// raquette sont en J2000, la monture (comme LX200/OnStep) travaille en coordonnees de la
// date : sans precession, l'ecart atteint 0,37 deg en 2026.
void precessToDate(double &ra_h, double &dec_d){
    double T = (julian_date(dt_y, dt_m, dt_d, 12.0) - 2451545.0) / 36525.0;
    double zeta = (2306.2181*T + 0.30188*T*T + 0.017998*T*T*T) / 3600.0 * DEGRAD;
    double z    = (2306.2181*T + 1.09468*T*T + 0.018203*T*T*T) / 3600.0 * DEGRAD;
    double th   = (2004.3109*T - 0.42665*T*T - 0.041833*T*T*T) / 3600.0 * DEGRAD;
    double a = ra_h * 15.0 * DEGRAD + zeta, d = dec_d * DEGRAD;
    double A = cos(d) * sin(a);
    double B = cos(th) * cos(d) * cos(a) - sin(th) * sin(d);
    double C = sin(th) * cos(d) * cos(a) + cos(th) * sin(d);
    ra_h  = rev((atan2(A, B) + z) * RADEG) / 15.0;
    dec_d = atan2(C, sqrt(A*A + B*B)) * RADEG;
}

// Synchronisation sur une cible ; ofDate : coordonnees deja de la date (Systeme solaire)
void cmd_sync_on(double ra_h, double dec_d, bool ofDate){
    if (!ofDate) precessToDate(ra_h, dec_d);
    mega_cmd(":Sr"+formatRA(ra_h));
    mega_cmd(":Sd"+formatDEC(dec_d));
    mega_cmd(":CM");
}

// GoTo ; ofDate : coordonnees deja de la date (Systeme solaire), sinon J2000 (catalogues).
// La cible est gardee en coordonnees de la date, comme :Gr/:Gd de la monture (reprise, temps restant).
void cmd_goto(double ra_h, double dec_d, bool ofDate){
    if (!ofDate) precessToDate(ra_h, dec_d);
    targetRA = ra_h;
    targetDEC = dec_d;
    if (currentCat == CAT_SYSSOL && !selectedIsStar) {
        if (selectedObj.id == 0) mega_cmd(":TS#");
        else if (selectedObj.id == 1) mega_cmd(":TL#");
        else mega_cmd(":TQ#");
    } else {
        mega_cmd(":TQ#");
    }
    mega_cmd(":Sr"+formatRA(ra_h));
    mega_cmd(":Sd"+formatDEC(dec_d));
    String resp=mega_cmd(":MS");
    if(resp.startsWith("0")){
        uiState=UI_SLEWING;
    } else {
        char buf[21]; snprintf(buf,21,"%-20s",resp.c_str());
        showMessage("  !! IMPOSSIBLE !!  ", buf, 2500, UI_OBJECT_INFO);
    }
    lcdNeedsRefresh=true;
}

void cmd_stop()           { 
    mega_cmd(":Qn",false); mega_cmd(":Qs",false); mega_cmd(":Qe",false); mega_cmd(":Qw",false);
    m_isTracking=false; m_isSlewing=false; 
}
void cmd_toggleTracking() {
    if(m_isTracking) mega_cmd(":Td",false);
    else             mega_cmd(":Te",false);
}

void cmd_setSpeed(double s){
    int nnn = (int)(s*10);
    if(nnn < 5)  nnn = 5;
    if(nnn > 40) nnn = 40;
    String c = ":BV "; c += String(nnn);
    mega_cmd(c);
    m_slewSpeed = nnn / 10.0;
}

void cmd_parking()         { mega_cmd(":hP"); }
void cmd_sync()            { mega_cmd(":CM"); }

void showMessage(const char* line0, const char* line1, unsigned long ms, int returnTo) {
    snprintf(uiMsgL0, 21, "%-20s", line0);
    snprintf(uiMsgL1, 21, "%-20s", line1);
    uiMsgUntil  = millis() + ms;
    uiMsgReturn = returnTo;
    uiState     = UI_MESSAGE;
    lcdNeedsRefresh = true;
}

// [v6.3] Synchronisation GPS automatique avant edition menu

float current_lst = -1.0;
unsigned long lst_sync_millis = 0;

float getCurrentLST() {
    if (current_lst < 0) return -1.0;
    float elapsed_h = (millis() - lst_sync_millis) * 1.0027379 / 3600000.0;
    float lst = current_lst + elapsed_h;
    while (lst >= 24.0) lst -= 24.0;
    return lst;
}

bool isVisible(float ra_h, float dec_deg) {
    float lst = getCurrentLST();
    if (lst < 0) return true; // Si pas d'heure siderale, on suppose visible
    float ha_h = lst - ra_h;
    float ha_rad = ha_h * 15.0 * (PI / 180.0);
    float dec_rad = dec_deg * (PI / 180.0);
    float lat_rad = obs_lat * (PI / 180.0);
    
    float sin_alt = sin(dec_rad)*sin(lat_rad) + cos(dec_rad)*cos(lat_rad)*cos(ha_rad);
    float alt_rad = asin(sin_alt);
    float alt_deg = alt_rad * (180.0 / PI);
    return alt_deg > 10.0;
}

void syncDataFromMega() {
    String gt = mega_cmd(":GL#");
    String gc = mega_cmd(":GC#");
    String glat = mega_cmd(":Gt#");
    String glon = mega_cmd(":Gg#");

    String gs = mega_cmd(":GS#");
    String gg = mega_cmd(":GG#");
    if (gg.length() >= 2) utcOffLx = gg.toFloat();

    if(gt.length() >= 8 && gc.length() >= 8) {
        dt_hr = gt.substring(0,2).toInt();
        dt_min = gt.substring(3,5).toInt();
        dt_sec = gt.substring(6,8).toInt();
        dt_m = gc.substring(0,2).toInt();
        dt_d = gc.substring(3,5).toInt();
        dt_y = 2000 + gc.substring(6,8).toInt();
    }
    if(glat.length() >= 6) {
        float sign = (glat.charAt(0) == '-') ? -1.0 : 1.0;
        float deg = glat.substring(1,3).toFloat();
        float mn = glat.substring(4,6).toFloat();
        obs_lat = sign * (deg + mn/60.0);
    }
    if(glon.length() >= 7) {
        float sign = (glon.charAt(0) == '-') ? -1.0 : 1.0;
        float deg = glon.substring(1,4).toFloat();
        float mn = glon.substring(5,7).toFloat();
        // Protocole OnStep : '-' = EST positif local
        obs_lon = (sign < 0) ? (deg + mn/60.0) : -(deg + mn/60.0);
    }
    if(gs.length() >= 8) {
        float h = gs.substring(0,2).toFloat();
        float m = gs.substring(3,5).toFloat();
        float s = gs.substring(6,8).toFloat();
        current_lst = h + m/60.0 + s/3600.0;
        lst_sync_millis = millis();
    }
}

// ============================================================
// SECTION 9 : ACCÈS CATALOGUES
// ============================================================
uint32_t getCatalogCount(CatID c){
    switch(c){
        case CAT_MESSIER:  return MESSIER_COUNT;
        case CAT_NGC:      return NGC_COUNT;
        case CAT_IC:       return IC_COUNT;
        case CAT_PK:       return PK_COUNT;
        case CAT_CALDWELL: return CALDWELL_COUNT;
        case CAT_BSC:      return BSC_COUNT;
        case CAT_SYSSOL:
            if(!timeFetched) { syncDataFromMega(); timeFetched = true; }
            // dt_* est l'heure locale de la monture (:GL) ; les ephemerides veulent l'UTC (UTC = locale + :GG)
            computeSysSol(dt_y, dt_m, dt_d, dt_hr, dt_min, dt_sec + (int)lround(utcOffLx * 3600.0));
            return SYSSOL_COUNT;
        default: return 0;
    }
}

bool getObj(CatID c, uint32_t i, DeepSkyObject &out){
    if(c==CAT_BSC) return false;
    switch(c){
        case CAT_MESSIER:  out=getObjectFromCatalog(catalogM,        i); return true;
        case CAT_NGC:      out=getObjectFromCatalog(catalogNGC,      i); return true;
        case CAT_IC:       out=getObjectFromCatalog(catalogIC,       i); return true;
        case CAT_PK:       out=getObjectFromCatalog(catalogPK,       i); return true;
        case CAT_CALDWELL: out=getObjectFromCatalog(catalogCaldwell, i); return true;
        default: return false;
    }
}

const char* getCatPrefix(CatID c){
    switch(c){
        case CAT_MESSIER:  return "M";
        case CAT_NGC:      return "NGC";
        case CAT_IC:       return "IC";
        case CAT_PK:       return "PK";
        case CAT_CALDWELL: return "C";
        case CAT_BSC:      return "*";
        default: return "?";
    }
}

void selectCurrentObject(){
    if(currentCat == CAT_SYSSOL) {
        selectedIsStar = false;
        selectedObj.id = objectIndex;
        selectedObj.ra = sysSolObjs[objectIndex].ra;
        selectedObj.dec = sysSolObjs[objectIndex].dec;
        selectedObj.mag = 0;
        selectedObj.type = 255;
        return;
    }
    if(currentCat==CAT_BSC){
        selectedStar=getStarFromCatalog(objectIndex);
        selectedIsStar=true;
    } else {
        getObj(currentCat,objectIndex,selectedObj);
        selectedIsStar=false;
    }
}

// ============================================================
// SECTION 10 : AFFICHAGE LCD
// ============================================================
void lcdLine(uint8_t row, const char* str){
    if (row >= 4) return;
    lcd.setCursor(0,row);
    char buf[21]; snprintf(buf,21,"%-20s",str);
    lcd.print(buf);
}

void printMain(){
    char buf[21];
    
    if (mountType == 0 && !displayRaDec) {
        long az_sec = round(fabs(m_currentAz) * 3600.0);
        int az_d = az_sec / 3600;
        int az_m = (az_sec % 3600) / 60;
        int az_s = az_sec % 60;
        
        bool alt_neg = (m_currentAlt < 0);
        long alt_sec = round(fabs(m_currentAlt) * 3600.0);
        int alt_d = alt_sec / 3600;
        int alt_m = (alt_sec % 3600) / 60;
        int alt_s = alt_sec % 60;

        snprintf(buf,21,"AZ: %03d%c%02d'%02d\"", az_d, 0xDF, az_m, az_s);
        lcdLine(0,buf);
        snprintf(buf,21,"ALT: %c%02d%c%02d'%02d\"", alt_neg?'-':'+', alt_d, 0xDF, alt_m, alt_s);
        lcdLine(1,buf);
    } else {
        bool dneg=(m_currentDEC<0); double adec=fabs(m_currentDEC);
        int dd=(int)adec, dm=(int)((adec-dd)*60.0), ds=(int)(((adec-dd)*60.0-dm)*60.0);
        int rh=(int)m_currentRA, rm=(int)((m_currentRA-rh)*60.0), rs=(int)(((m_currentRA-rh)*60.0-rm)*60.0);

        snprintf(buf,21,"RA: %02dh%02dm%02ds", rh, rm, rs);
        lcdLine(0,buf);
        snprintf(buf,21,"DEC: %c%02d%c%02d'%02d\"", dneg?'-':'+', dd, 0xDF, dm, ds);
        lcdLine(1,buf);
    }
    
    if(!m_online){
        lcdLine(2, isEnglish ? "STATE: NO CONNECTION" : "Etat: Non connectee");
    } else if(m_isPaused){
        lcdLine(2, "* EN PAUSE *");
    } else if(m_isParked){
        lcdLine(2, "* PARQUEE *");
    } else if(m_limitHit){
        lcdLine(2, "!! LIMITE !!");
    } else {
        String mType = "AltAz";
        if (mountType == 1) mType = "Fourche";
        if (mountType == 2) mType = "Germ";
        
        String tState = isEnglish ? "Stop" : "Arret";
        if (m_isTracking) {
            tState = isEnglish ? "Track" : "Suivi";
        }
        
        String objStr = "";
        if (m_isTracking && trackedObjectName.length() > 0) {
            objStr = "-" + trackedObjectName;
        }

        char stBuf[40];
        if (!motorPowerOn) {
            snprintf(stBuf, 40, "%s-%s(OFF)", mType.c_str(), tState.c_str());
        } else {
            snprintf(stBuf, 40, "%s-%s%s", mType.c_str(), tState.c_str(), objStr.c_str());
        }

        int len = strlen(stBuf);
        if (len > 20) {
            static unsigned long lastScroll = 0;
            static int scrollIdx = 0;
            if (millis() - lastScroll > 400) {
                lastScroll = millis();
                scrollIdx++;
                if (scrollIdx > len - 20 + 4) scrollIdx = 0; // Pause at the end
            }
            int dispIdx = scrollIdx;
            if (dispIdx > len - 20) dispIdx = len - 20;
            
            char dispBuf[21];
            strncpy(dispBuf, stBuf + dispIdx, 20);
            dispBuf[20] = '\0';
            lcdLine(2, dispBuf);
        } else {
            lcdLine(2, stBuf);
        }
    }
    lcdLine(3, isEnglish ? "[ENT] = Menu        " : "[ENT] = Menu        ");
}

void printMessage(){
    lcd.clear();
    lcdLine(0, uiMsgL0);
    lcdLine(1, uiMsgL1);
}

const char* getCatName(int idx) {
    if (idx < 0 || idx >= CAT_COUNT) return "";
    if (isEnglish) {
        const char* const NAMES_EN[] = {
            "Messier", "NGC", "IC", "PK", "Caldwell", "Stars", "Sol"
        };
        return NAMES_EN[idx];
    }
    return CAT_NAMES[idx];
}

void printCatSelect(){
    lcdLine(0, isEnglish ? "[ SELECT CATALOG ]" : "[ CHOIX CATALOGUE ]");
    char buf[21];
    snprintf(buf, 21,"> %-15s", getCatName((int)currentCat));
    lcdLine(1,buf);
    snprintf(buf,21,"  (%lu obj)", getCatalogCount((CatID)currentCat));
    lcdLine(2,buf);
    lcdLine(3, isEnglish ? "  [UP/DWN] Select" : "  [HAUT/BAS] Choisir");
}

void printObjectList(){
    char buf[21];
    snprintf(buf, 21,"[%s] %lu obj", getCatName((int)currentCat), getCatalogCount((CatID)currentCat));
    lcdLine(0,buf);

    uint32_t total=getCatalogCount(currentCat);
    if(total==0){ 
        lcdLine(1," Aucun objet"); 
        lcdLine(2,"");
        lcdLine(3,"");
        return; 
    }

    char line[21];
    float mag = 0;
    double ra = 0, dec = 0;
    
    if(currentCat==CAT_BSC){
        StarObject s=getStarFromCatalog((uint32_t)objectIndex);
        char ast = isVisible(s.ra, s.dec) ? '*' : ' ';
        snprintf(line, 21,"> %s%c", s.name, ast);
        mag = s.mag/10.0f;
        ra = s.ra; dec = s.dec;
    } else if(currentCat==CAT_SYSSOL){
        char ast = isVisible(sysSolObjs[objectIndex].ra, sysSolObjs[objectIndex].dec) ? '*' : ' ';
        snprintf(line, 21,"> %s%c", sysSolObjs[objectIndex].name, ast);
        mag = 0; // Not available
        ra = sysSolObjs[objectIndex].ra; dec = sysSolObjs[objectIndex].dec;
    } else {
        DeepSkyObject o; getObj(currentCat,(uint32_t)objectIndex,o);
        char ast = isVisible(o.ra, o.dec) ? '*' : ' ';
        snprintf(line, 21,"> %s%d%c", getCatPrefix(currentCat), o.id, ast);
        mag = o.mag/10.0f;
        ra = o.ra; dec = o.dec;
    }
    lcdLine(1,line);
    
    if (currentCat!=CAT_SYSSOL) {
        snprintf(buf,21,"  Mag: %.1f", mag);
        lcdLine(2,buf);
    } else {
        lcdLine(2,"");
    }
    
    int rah=(int)ra;
    int ram=(int)((ra-rah)*60);
    int dd=(int)fabs(dec);
    snprintf(buf,21,"  %02dh%02d %c%02d%c", rah,ram, dec<0?'-':'+', dd, 0xDF);
    lcdLine(3,buf);
}

void printObjectInfo(){
    char buf[21];
    double ra = 0, dec = 0;
    
    if (currentCat == CAT_SYSSOL) {
        char ast = isVisible(sysSolObjs[objectIndex].ra, sysSolObjs[objectIndex].dec) ? '*' : ' ';
        snprintf(buf,21,"OBJET: %s%c",sysSolObjs[objectIndex].name, ast);
        ra = sysSolObjs[objectIndex].ra; dec = sysSolObjs[objectIndex].dec;
    } else if(selectedIsStar){
        char ast = isVisible(selectedStar.ra, selectedStar.dec) ? '*' : ' ';
        snprintf(buf,21,"OBJET: %s%c",selectedStar.name, ast);
        ra = selectedStar.ra; dec = selectedStar.dec;
    } else {
        char ast = isVisible(selectedObj.ra, selectedObj.dec) ? '*' : ' ';
        snprintf(buf,21,"OBJET: %s%d%c", getCatPrefix(currentCat), selectedObj.id, ast);
        ra = selectedObj.ra; dec = selectedObj.dec;
    }
    lcdLine(0,buf);
    
    int rah=(int)ra, ram=(int)((ra-rah)*60);
    snprintf(buf,21,"RA: %02dh%02dm", rah,ram);
    lcdLine(1,buf);
    
    int dd=(int)fabs(dec), dm=(int)((fabs(dec)-dd)*60);
    snprintf(buf,21,"DEC: %c%02d%c%02d'", dec<0?'-':'+', dd, 0xDF, dm);
    lcdLine(2,buf);
    
    lcdLine(3, "[ENT]=GOTO [>]=SYNC");
}

void printSlewing(){
    char anim_chars[] = {'*', '+', 'x', '+'};
    char anim = anim_chars[(millis() / 250) % 4];
    char b0[21];
    
    if (isParkingWorkflow) {
        snprintf(b0, 21, isEnglish ? "PARKING IN PROG %c" : "PARKING EN COURS %c", anim);
        lcdLine(0, b0);
        
        double az_diff = fabs(m_currentAz - m_parkAz);
        if (az_diff > 180.0) az_diff = 360.0 - az_diff;
        double alt_diff = fabs(m_currentAlt - m_parkAlt);
        
        char buf[21];
        if (mountType == 0) {
            snprintf(buf, 21, "dAZ:%5.1f%c dAL:%4.1f%c", az_diff, 0xDF, alt_diff, 0xDF);
        } else {
            // For equatorial, Az is RA axis and Alt is DEC axis
            snprintf(buf, 21, "dRA:%5.1f%c dDE:%4.1f%c", az_diff, 0xDF, alt_diff, 0xDF);
        }
        lcdLine(1, buf);
        lcdLine(2, "");
        lcdLine(3, isEnglish ? "[<] Cancel" : "[<] Annuler");
    } else {
        snprintf(b0, 21, isEnglish ? "SLEWING TO TGT %c" : "GOTO EN COURS... %c", anim);
        lcdLine(0, b0);
        
        double ra  = selectedIsStar?selectedStar.ra  :selectedObj.ra;
        double dec = selectedIsStar?selectedStar.dec :selectedObj.dec;
        double c_dec_rad = m_currentDEC * DEGRAD;
        double t_dec_rad = dec * DEGRAD;
        double d_ra_rad = (m_currentRA - ra) * 15.0 * DEGRAD;
        double cos_dist = sin(c_dec_rad) * sin(t_dec_rad) + cos(c_dec_rad) * cos(t_dec_rad) * cos(d_ra_rad);
        if (cos_dist < -1.0) cos_dist = -1.0;
        if (cos_dist > 1.0) cos_dist = 1.0;
        if (cos_dist > 1.0) cos_dist = 1.0;
        double speed = m_slewSpeed;
        if (speed < 0.05) speed = 3.0;

        static double last_target_ra = -1.0;
        static unsigned long slewStartMs = 0;
        static double initialEta = 0.0;

        double ra_diff = fabs(m_currentRA - ra) * 15.0;
        if (ra_diff > 180.0) ra_diff = 360.0 - ra_diff;
        double dec_diff = fabs(m_currentDEC - dec);
        double max_dist = (ra_diff > dec_diff) ? ra_diff : dec_diff;

        float lst = getCurrentLST();
        if (lst >= 0.0 && mountType == 2) {
            float ha_target = fmod((lst - ra) * 15.0, 360.0);
            if (ha_target < 0) ha_target += 360.0;
            float target_az, target_alt;
            if (ha_target >= 0.0 && ha_target < 180.0) {
                target_az = ha_target;
                target_alt = dec;
            } else {
                target_az = fmod(ha_target + 180.0, 360.0);
                target_alt = 180.0 - dec;
            }
            double az_diff = fabs(m_currentAz - target_az);
            if (az_diff > 180.0) az_diff = 360.0 - az_diff;
            double alt_diff = fabs(m_currentAlt - target_alt);
            // target_alt can be up to 270 (if dec=-90), and m_currentAlt up to 270.
            double phys_max = (az_diff > alt_diff) ? az_diff : alt_diff;
            if (phys_max > max_dist) max_dist = phys_max;
        }

        if (ra != last_target_ra) {
            last_target_ra = ra;
            slewStartMs = millis();
            
            double d_ramp = (speed * 5.0) / 2.0;
            if (max_dist >= 2.0 * d_ramp) {
                double coasting_dist = max_dist - 2.0 * d_ramp;
                initialEta = 10.0 + (coasting_dist / speed);
            } else {
                initialEta = 2.0 * sqrt(5.0 * max_dist / speed);
            }
        }

        unsigned long elapsed = (millis() - slewStartMs) / 1000;
        int eta = (int)initialEta - (int)elapsed;
        if (eta < 0) eta = 0;

        char buf[21];
        if (mountType == 0) {
            // For Alt-Az, we just show the direct remaining distance on the sky for simplicity, 
            // since we don't have target Alt/Az computed here.
            // Wait, we can compute target Alt/Az!
            float lst = getCurrentLST();
            double ha = (lst - ra) * 15.0;
            double ha_rad = ha * DEGRAD;
            double dec_rad = dec * DEGRAD;
            double lat_rad = obs_lat * DEGRAD;
            double sin_alt = sin(dec_rad)*sin(lat_rad) + cos(dec_rad)*cos(lat_rad)*cos(ha_rad);
            double target_alt = asin(sin_alt) * RADEG;
            double cos_az = (sin(dec_rad) - sin_alt*sin(lat_rad)) / (cos(asin(sin_alt))*cos(lat_rad));
            double target_az = acos(constrain(cos_az, -1.0, 1.0)) * RADEG;
            if (sin(ha_rad) > 0) target_az = 360.0 - target_az;

            double az_diff = fabs(m_currentAz - target_az);
            if (az_diff > 180.0) az_diff = 360.0 - az_diff;
            double alt_diff = fabs(m_currentAlt - target_alt);
            
            snprintf(buf, 21, "dAZ:%5.1f%c dAL:%4.1f%c", az_diff, 0xDF, alt_diff, 0xDF);
        } else {
            snprintf(buf, 21, "dRA:%5.1f%c dDE:%4.1f%c", ra_diff, 0xDF, dec_diff, 0xDF);
        }
        lcdLine(1, buf);
        lcdLine(2, "");
        lcdLine(3, isEnglish ? "[<] Cancel GOTO" : "[<] Annuler GOTO");
    }
}

void printSpeed(){
    char buf[21];
    lcdLine(0, isEnglish ? "[ GOTO SPEED ]" : "[ VITESSE GOTO ]");
    if(m_online) {
        snprintf(buf, 21," > %.1f deg/s", temp_slewSpeed);
        lcdLine(1,buf);
        lcdLine(2,"");
        lcdLine(3, isEnglish ? "[UP/DWN] Edit" : "[HAUT/BAS] Edit");
    } else {
        lcdLine(1," > --- deg/s");
        lcdLine(2,"");
        lcdLine(3,"");
    }
}

void printSettings() {
    lcdLine(0, isEnglish ? "[ SETTINGS ]" : "[ REGLAGES ]");
    const char* opts[] = {
        "Catalogues",
        isEnglish ? "GoTo Custom" : "GoTo Manuel",
        isEnglish ? "Parking" : "Parking", 
        m_isPaused ? (isEnglish ? "Resume Track" : "Reprendre Suivi") : (isEnglish ? "Pause Track" : "Pause Suivi"),
        isEnglish ? "Spiral Search" : "Rech. Spirale", 
        isEnglish ? "Motor Power" : "Alim Moteurs", 
        isEnglish ? "GoTo Speed" : "Vitesse GoTo", 
        "Buzzer", 
        isEnglish ? "Sync/Align" : "Synchroniser", 
        isEnglish ? "Mount Type" : "Type Monture",
        (mountType == 0) ? "Ratio AZ" : "Ratio RA",
        (mountType == 0) ? "Ratio ALT" : "Ratio DEC",
        isEnglish ? "Date/Time" : "Date/Heure", 
        isEnglish ? "Location" : "Lieu Obs.", 
        isEnglish ? "Language" : "Langue",
        "GPS Auto",
        isEnglish ? "Coord Display" : "Affichage Coord"
    };
    
    char b1[21], b2[21], b3[21];
    int start = settingsSel;
    if (start > 17 - 3) start = 17 - 3;
    
    snprintf(b1, 21, "%c %s", (settingsSel == start) ? '>' : ' ', opts[start]);
    snprintf(b2, 21, "%c %s", (settingsSel == start + 1) ? '>' : ' ', opts[start + 1]);
    snprintf(b3, 21, "%c %s", (settingsSel == start + 2) ? '>' : ' ', opts[start + 2]);
    
    lcdLine(1, b1);
    lcdLine(2, b2);
    lcdLine(3, b3);
}

void printAlignCenter(){
    char buf[21];
    if (selectedIsStar) {
        snprintf(buf, 21, isEnglish ? "Center %s" : "Centrez %s", selectedStar.name);
    } else {
        snprintf(buf, 21, isEnglish ? "Center %s%d" : "Centrez %s%d", getCatPrefix(currentCat), selectedObj.id);
    }
    lcdLine(0, buf);
    lcdLine(1, "   ENT=SYNC     ");
    lcdLine(2, "");
    lcdLine(3, "");
}

void printAlign(){
    lcdLine(0, "SYNCHRONISATION");
    lcdLine(1, "ENT=OK  <=RET");
    lcdLine(2, "");
    lcdLine(3, "");
}

void printParking(){
    lcdLine(0, isEnglish ? "[ PARKING ]" : "[ PARKING ]");
    const char* opt0 = isEnglish ? "Park" : "Parquer";
    const char* opt1 = isEnglish ? "Unpark" : "Deparquer";
    const char* opt2 = isEnglish ? "Set Pos" : "Definir Pos";
    
    char b1[21], b2[21], b3[21];
    snprintf(b1, 21, "%c %s", (parkSel == 0) ? '>' : ' ', opt0);
    snprintf(b2, 21, "%c %s", (parkSel == 1) ? '>' : ' ', opt1);
    snprintf(b3, 21, "%c %s", (parkSel == 2) ? '>' : ' ', opt2);
    
    lcdLine(1, b1);
    lcdLine(2, b2);
    lcdLine(3, b3);
}

void sendLocationToMega() {
    char buf[16];
    int lat_deg = abs(obs_lat);
    int lat_min = (abs(obs_lat) - lat_deg) * 60;
    snprintf(buf, 16, ":St%c%02d*%02d", obs_lat>=0?'+':'-', lat_deg, lat_min);
    mega_cmd(buf);
    int lon_deg = abs(obs_lon);
    int lon_min = (abs(obs_lon) - lon_deg) * 60;
    // LX200 : Ouest positif (meme convention que la lecture :Gg de syncDataFromMega)
    snprintf(buf, 16, ":Sg%c%03d*%02d", obs_lon>=0?'-':'+', lon_deg, lon_min);
    mega_cmd(buf);
}

void refreshLcd(){
    // LCD I2C standard (pas de gestion couleur RGB)
    switch(uiState){
        case UI_MAIN:        printMain();       break;
        case UI_CAT_SELECT:  printCatSelect();  break;
        case UI_OBJECT_LIST: printObjectList(); break;
        case UI_OBJECT_INFO: printObjectInfo(); break;
        case UI_SLEWING:     printSlewing();    break;
        case UI_SPIRAL:
            lcdLine(0, isEnglish ? "[ SPIRAL SEARCH ]" : "[ RECH. SPIRALE ]");
            lcdLine(1, isEnglish ? "  Searching...  " : "  En cours...   ");
            lcdLine(2, "");
            lcdLine(3, isEnglish ? "[<] Cancel Search" : "[<] Annuler     ");
            break;
        case UI_SPEED:       printSpeed();      break;
        case UI_SETTINGS:    printSettings();   break;
        case UI_ALIGN:       printAlign();      break;
        case UI_ALIGN_CENTER:printAlignCenter();break;
        case UI_PARKING:     printParking();    break;
        case UI_MESSAGE:     printMessage();    break;
        
        case UI_MOUNT: {
            lcdLine(0, "[ TYPE MONTURE ]");
            if(m_online) {
                lcdLine(1, temp_mountType == 0 ? "> AltAz         " : "  AltAz         ");
                lcdLine(2, temp_mountType == 1 ? "> ForkEq        " : "  ForkEq        ");
                lcdLine(3, temp_mountType == 2 ? "> GermanEq      " : "  GermanEq      ");
            } else {
                lcdLine(1, "  ---           ");
                lcdLine(2, "  ---           ");
                lcdLine(3, "  ---           ");
            }
            break;
        }
        case UI_RATIO_AZ: {
            lcdLine(0, "[ RATIO AZ/RA ]");
            if(m_online) {
                char buf[21]; snprintf(buf, 21," 1:%.0f", temp_gearRatioAZ);
                lcdLine(1, buf);
                extern float ratioStep;
                snprintf(buf, 21," Pas: %.0f", ratioStep);
                lcdLine(2, buf);
                lcdLine(3, isEnglish ? "[<>]=Pas [^v]=Modif" : "[<>]=Pas [^v]=Modif");
            } else {
                lcdLine(1, "> ---");
                lcdLine(2, "");
                lcdLine(3, "");
            }
            break;
        }
        case UI_RATIO_ALT: {
            lcdLine(0, "[ RATIO DEC/AL ]");
            if(m_online) {
                char buf[21]; snprintf(buf, 21," 1:%.0f", temp_gearRatioALT);
                lcdLine(1, buf);
                extern float ratioStep;
                snprintf(buf, 21," Pas: %.0f", ratioStep);
                lcdLine(2, buf);
                lcdLine(3, isEnglish ? "[<>]=Pas [^v]=Modif" : "[<>]=Pas [^v]=Modif");
            } else {
                lcdLine(1, "> ---");
                lcdLine(2, "");
                lcdLine(3, "");
            }
            break;
        }
        case UI_BEEP: {
            lcdLine(0, "[ REGLAGE BIP ]");
            if(m_online) {
                lcdLine(1, temp_buzzerOn ? "> ACTIF         " : "  ACTIF         ");
                lcdLine(2, temp_buzzerOn ? "  INACTIF       " : "> INACTIF       ");
                lcdLine(3, isEnglish ? "[UP/DWN] Select" : "[HAUT/BAS] Choisir");
            } else {
                lcdLine(1, "  ---           ");
                lcdLine(2, "  ---           ");
                lcdLine(3, "");
            }
            break;
        }
        case UI_EDIT_TIME: {
            lcdLine(0, "[ HEURE ]");
            char b[21];
            snprintf(b,21,"%02d/%02d %02d:%02d", dt_d, dt_m, dt_hr, dt_min);
            lcdLine(1,b);
            
            float lst = getCurrentLST();
            if (lst >= 0) {
                int lst_h = (int)lst;
                int lst_m = (int)((lst - lst_h) * 60);
                snprintf(b, 21, "LST: %02dh%02dm", lst_h, lst_m);
                lcdLine(2, b);
            } else {
                lcdLine(2, "LST: --h--");
            }
            
            lcdLine(3, isEnglish ? "[UP/DWN] Edit" : "[HAUT/BAS] Edit");
            break;
        }
        case UI_EDIT_LOCATION: {
            lcdLine(0, "[ LIEU ]");
            char b[17];
            snprintf(b,17,"La:%.1f Lo:%.1f", obs_lat, obs_lon);
            lcdLine(1,b);
            lcdLine(2, "");
            lcdLine(3, isEnglish ? "[UP/DWN] Edit" : "[HAUT/BAS] Edit");
            break;
        }
        case UI_MOTOR_POWER: {
            lcdLine(0, "[ ALIM MOTEURS ]");
            lcdLine(1, temp_motorPowerOn ? "> ACTIVE        " : "  ACTIVE        ");
            lcdLine(2, temp_motorPowerOn ? "  DESACTIVE     " : "> DESACTIVE     ");
            lcdLine(3, "[HAUT/BAS] Choisir");
            break;
        }
        case UI_LANGUAGE: {
            lcdLine(0, isEnglish ? "[ LANGUAGE ]" : "[ LANGUE ]");
            lcdLine(1, temp_isEnglish ? "> English       " : "  English       ");
            lcdLine(2, temp_isEnglish ? "  Francais      " : "> Francais      ");
            lcdLine(3, temp_isEnglish ? "[UP/DWN] Select" : "[HAUT/BAS] Choisir");
            break;
        }
        case UI_GPS: {
            lcdLine(0, "[ GPS ]");
            lcdLine(1, temp_gpsEnabled ? (isEnglish ? "> Auto enabled  " : "> Auto active   ") : (isEnglish ? "  Auto enabled  " : "  Auto active   "));
            lcdLine(2, temp_gpsEnabled ? (isEnglish ? "  Disabled      " : "  Desactive     ") : (isEnglish ? "> Disabled      " : "> Desactive     "));
            lcdLine(3, isEnglish ? "[UP/DWN] Select" : "[HAUT/BAS] Choisir");
            break;
        }
        case UI_COORD_MODE: {
            lcdLine(0, isEnglish ? "[ COORD MODE ]" : "[ AFFICHAGE ]");
            lcdLine(1, temp_displayRaDec ? "> RA/DEC        " : "  RA/DEC        ");
            lcdLine(2, temp_displayRaDec ? "  ALT/AZ        " : "> ALT/AZ        ");
            lcdLine(3, isEnglish ? "[UP/DWN] Select" : "[HAUT/BAS] Choisir");
            break;
        }
        case UI_MENU_SELECT: {
            lcdLine(0, "[ MENU ]");
            const char* opt0 = "Catalogues";
            const char* opt1 = m_isPaused ? "Reprendre Suivi" : "Pause Moteurs";
            const char* opt2 = "Reglages";
            
            char b1[21], b2[21], b3[21];
            snprintf(b1, 21, "%c %s", (menuSel == 0) ? '>' : ' ', opt0);
            snprintf(b2, 21, "%c %s", (menuSel == 1) ? '>' : ' ', opt1);
            snprintf(b3, 21, "%c %s", (menuSel == 2) ? '>' : ' ', opt2);
            
            lcdLine(1, b1);
            lcdLine(2, b2);
            lcdLine(3, b3);
            break;
        }
        case UI_CUSTOM_GOTO: {
            lcdLine(0, isEnglish ? "[ CUSTOM GOTO ]" : "[ GOTO MANUEL ]");
            char b[21];
            snprintf(b, 21, "RA:  %02dh %02dm %02ds", cgo_ra_h, cgo_ra_m, cgo_ra_s);
            if (editSel == 0) b[4] = '>'; else if (editSel == 1) b[8] = '>'; else if (editSel == 2) b[12] = '>';
            lcdLine(1, b);
            
            snprintf(b, 21, "DEC: %c%02d* %02d' %02d\"", cgo_dec_neg?'-':'+', cgo_dec_d, cgo_dec_m, cgo_dec_s);
            if (editSel == 3) b[4] = '>'; else if (editSel == 4) b[9] = '>'; else if (editSel == 5) b[13] = '>';
            lcdLine(2, b);
            
            lcdLine(3, isEnglish ? "[UP/DWN] Edit" : "[HAUT/BAS] Edit");
            break;
        }
        default: break;
    }
    lcdNeedsRefresh=false;
}

bool btnLatched[5] = {false, false, false, false, false};
bool btnReleaseLatched[5] = {false, false, false, false, false};
bool btnReleased[5] = {false, false, false, false, false};

void readButtons(){
    unsigned long now=millis();
    for(int i=0;i<5;i++){
        bool raw=(digitalRead(BTN_PINS[i])==LOW);
        if(raw!=btnPrev[i]) btnTime[i]=now;
        bool newState=(now-btnTime[i]>DEBOUNCE_MS)?raw:btnState[i];
        
        if(newState && !btnState[i]) {
            btnHoldTime[i]=now;
            btnLatched[i]=true;
        }
        if(!newState && btnState[i]) {
            btnReleaseLatched[i]=true;
        }
        
        btnState[i]=newState;
        btnPrev[i]=raw;
    }
}

void detectPresses(){
    for(int i=0;i<5;i++){
        btnPressed[i] = btnLatched[i];
        btnLatched[i] = false;
        
        btnReleased[i] = btnReleaseLatched[i];
        btnReleaseLatched[i] = false;
        
        btnWas[i]=btnState[i];
    }
}

int fastScroll(int btnIdx, int dir){
    if(btnState[btnIdx] && millis()-btnHoldTime[btnIdx] > 600){
        static unsigned long lastFast=0;
        if(millis()-lastFast > FAST_SCROLL_DELAY){
            lastFast=millis();
            return dir * FAST_SCROLL_STEP;
        }
        return 0;
    }
    return btnPressed[btnIdx] ? dir : 0;
}

void scrollList(int delta){
    uint32_t total=getCatalogCount(currentCat);
    if(total==0) return;
    long newIdx=(long)objectIndex+delta;
    if(newIdx<0) newIdx=0;
    if((uint32_t)newIdx>=total) newIdx=total-1;
    objectIndex=(uint32_t)newIdx;
}

void handleButtons(){
    readButtons(); detectPresses();
    bool up    =btnPressed[BTN_IDX_UP] && !btnReleased[BTN_IDX_UP];
    bool down  =btnPressed[BTN_IDX_DOWN] && !btnReleased[BTN_IDX_DOWN];
    bool left  =btnPressed[BTN_IDX_LEFT] && !btnReleased[BTN_IDX_LEFT];
    bool right =btnPressed[BTN_IDX_RIGHT] && !btnReleased[BTN_IDX_RIGHT];
    bool enter =btnPressed[BTN_IDX_ENTER] && !btnReleased[BTN_IDX_ENTER];

    static bool manualSlewing[4] = {false, false, false, false}; // up, down, left, right

    if(uiState == UI_MAIN) {
        if (!m_isSlewing) {
            if(up)    { mega_cmd(":Mn", false); manualSlewing[0] = true; }
            if(down)  { mega_cmd(":Ms", false); manualSlewing[1] = true; }
            if(left)  { mega_cmd(":Me", false); manualSlewing[2] = true; }
            if(right) { mega_cmd(":Mw", false); manualSlewing[3] = true; }
        }

        if(btnReleased[BTN_IDX_UP] && manualSlewing[0]) {
            mega_cmd(":Qn", false); manualSlewing[0] = false;
        }
        if(btnReleased[BTN_IDX_DOWN] && manualSlewing[1]) {
            mega_cmd(":Qs", false); manualSlewing[1] = false;
        }
        if(btnReleased[BTN_IDX_LEFT] && manualSlewing[2]) {
            mega_cmd(":Qe", false); manualSlewing[2] = false;
        }
        if(btnReleased[BTN_IDX_RIGHT] && manualSlewing[3]) {
            mega_cmd(":Qw", false); manualSlewing[3] = false;
        }
        
        // Safety: If for some reason multiple keys are released, ensure we stop
        for(int i=0; i<4; i++) {
            if(btnReleased[i] && !manualSlewing[0] && !manualSlewing[1] && !manualSlewing[2] && !manualSlewing[3]) {
                // If a button is released but we didn't track a slew, and we are not slewing a GoTo, stop anyway just in case
                if (!m_isSlewing) {
                    mega_cmd(":Qn", false);
                    mega_cmd(":Qs", false);
                    mega_cmd(":Qe", false);
                    mega_cmd(":Qw", false);
                }
            }
        }
    }

    int scrollDelta=0;
    if(uiState==UI_OBJECT_LIST){
        scrollDelta+=fastScroll(BTN_IDX_UP,   -1);
        scrollDelta+=fastScroll(BTN_IDX_DOWN, +1);
    }
    if(scrollDelta!=0){ 
        scrollList(scrollDelta); 
        lcdNeedsRefresh=true; 
        extern unsigned long lastLcd;
        lastLcd = 0;
        return; 
    }

    if(!up&&!down&&!left&&!right&&!enter) return;
    lcdNeedsRefresh=true;
    extern unsigned long lastLcd;
    lastLcd = 0; // Force immediate refresh

    switch(uiState){

        case UI_MAIN:
            if(enter) { settingsSel=0; uiState=UI_SETTINGS; }
            break;

        case UI_MENU_SELECT:
            // Obsolete state, kept to avoid compilation errors if referenced elsewhere
            uiState=UI_MAIN;
            break;

        case UI_CAT_SELECT:
            if(up)         { currentCat=(CatID)(((int)currentCat-1+CAT_COUNT)%CAT_COUNT); objectIndex=0; }
            if(down)       { currentCat=(CatID)(((int)currentCat+1)%CAT_COUNT); objectIndex=0; }
            if(left)       { uiState=UI_MENU_SELECT; }
            if(right||enter){ uiState=UI_OBJECT_LIST; objectIndex=0; }
            break;

        case UI_OBJECT_LIST:
            if(up)         { scrollList(-1); }
            if(down)       { scrollList(+1); }
            if(left)       { uiState=UI_CAT_SELECT; }
            if(right||enter){ selectCurrentObject(); uiState=UI_OBJECT_INFO; }
            break;

        case UI_OBJECT_INFO: {
            uint32_t total=getCatalogCount(currentCat);
            if(left)  { uiState=UI_OBJECT_LIST; isAlignWorkflow = false; }
            if(up)    { if(objectIndex>0) objectIndex--; else objectIndex=total-1;
                        selectCurrentObject(); }
            if(down)  { objectIndex=(objectIndex<total-1)?objectIndex+1:0;
                        selectCurrentObject(); }
            if(right) {
                double ra = 0, dec = 0;
                if(currentCat == CAT_SYSSOL) { ra = sysSolObjs[objectIndex].ra; dec = sysSolObjs[objectIndex].dec; }
                else if(selectedIsStar) { ra = selectedStar.ra; dec = selectedStar.dec; }
                else { ra = selectedObj.ra; dec = selectedObj.dec; }
                
                if (!isVisible(ra, dec)) {
                    showMessage(isEnglish ? " BELOW HORIZON! " : " SOUS HORIZON ! ", "                ", 2000, UI_OBJECT_INFO);
                    return;
                }
                cmd_sync_on(ra, dec, currentCat == CAT_SYSSOL);
                showMessage(isEnglish ? "  SYNCHRONIZED  " : "  SYNCHRONISE   ", "                ", 1500, UI_MAIN);
            }
            if(enter) {
                double ra = 0, dec = 0;
                char objName[16] = "";
                if(currentCat == CAT_SYSSOL) { 
                    ra = sysSolObjs[objectIndex].ra; dec = sysSolObjs[objectIndex].dec; 
                    strncpy(objName, sysSolObjs[objectIndex].name, 15);
                }
                else if(selectedIsStar) { 
                    ra = selectedStar.ra; dec = selectedStar.dec; 
                    strncpy(objName, selectedStar.name, 15);
                }
                else { 
                    ra = selectedObj.ra; dec = selectedObj.dec; 
                    snprintf(objName, 16, "%s%d", getCatPrefix(currentCat), selectedObj.id);
                }
                
                if (!isVisible(ra, dec)) {
                    showMessage(isEnglish ? " BELOW HORIZON! " : " SOUS HORIZON ! ", "                ", 2000, UI_OBJECT_INFO);
                    return;
                }
                trackedObjectName = String(objName);
                cmd_goto(ra, dec, currentCat == CAT_SYSSOL);
                if (isAlignWorkflow) {
                    uiState = UI_ALIGN_CENTER;
                }
            }
            break;
        }

        case UI_SLEWING:
            if(enter||left){ cmd_stop(); uiState=UI_MAIN; isParkingWorkflow=false; }
            break;
        case UI_SPIRAL:
            if(enter||left){ mega_cmd(":XS0#", false); mega_cmd(":Q#", false); uiState=UI_MAIN; }
            break;
        case UI_SETTINGS:
            if(left)       { cmd_stop(); uiState=UI_MAIN; }
            if(up)         { settingsSel=(settingsSel-1+17)%17; }
            if(down)       { settingsSel=(settingsSel+1)%17; }
            if(right||enter){
                if(settingsSel==0) { cmd_stop(); currentCat=CAT_MESSIER; objectIndex=0; uiState=UI_CAT_SELECT; }
                else if(settingsSel==1) {
                    cgo_ra_h = (int)m_currentRA;
                    cgo_ra_m = (int)((m_currentRA - cgo_ra_h) * 60.0);
                    cgo_ra_s = (int)((m_currentRA - cgo_ra_h - cgo_ra_m/60.0) * 3600.0);
                    cgo_dec_neg = (m_currentDEC < 0);
                    double adec = fabs(m_currentDEC);
                    cgo_dec_d = (int)adec;
                    cgo_dec_m = (int)((adec - cgo_dec_d) * 60.0);
                    cgo_dec_s = (int)((adec - cgo_dec_d - cgo_dec_m/60.0) * 3600.0);
                    editSel = 0;
                    uiState = UI_CUSTOM_GOTO;
                }
                else if(settingsSel==2) uiState=UI_PARKING;
                else if(settingsSel==3) {
                    cmd_stop();
                    if (!m_isPaused) {
                        mega_cmd(":Td", false);
                        m_isPaused = true;
                        showMessage(isEnglish ? " MOTORS PAUSED  " : " MOTEURS EN PAUSE ", isEnglish ? "  Math preserved   " : "  Calculs gardes   ", 1500, UI_MAIN);
                    } else {
                        if (targetRA >= 0 && targetDEC >= -90) {
                            mega_cmd(":Sr" + formatRA(targetRA));
                            mega_cmd(":Sd" + formatDEC(targetDEC));
                            String resp = mega_cmd(":MS");
                            m_isPaused = false;
                            if (resp.startsWith("0")) {
                                showMessage(isEnglish ? " RESUMING TRACK " : " REPRISE SUIVI... ", isEnglish ? " Calc & Point. " : " Recalcul & Point. ", 1500, UI_SLEWING);
                            } else {
                                char buf[21]; snprintf(buf, 21, "%-20s", resp.c_str());
                                showMessage(isEnglish ? "  !! IMPOSSIBLE !!  " : "  !! IMPOSSIBLE !!  ", buf, 2500, UI_MAIN);
                            }
                        } else {
                            mega_cmd(":Te", false);
                            m_isPaused = false;
                            showMessage(isEnglish ? " RESUMING TRACK " : " REPRISE SUIVI... ", isEnglish ? "  No target...     " : "  Sans cible...    ", 1500, UI_MAIN);
                        }
                    }
                }
                else if(settingsSel==4) { mega_cmd(":XS1#", false); uiState=UI_SPIRAL; }
                else if(settingsSel==5) { temp_motorPowerOn = motorPowerOn; uiState=UI_MOTOR_POWER; }
                else if(settingsSel==6) { temp_slewSpeed = m_slewSpeed; uiState=UI_SPEED; }
                else if(settingsSel==7) { temp_buzzerOn = buzzerOn; uiState=UI_BEEP; }
                else if(settingsSel==8) uiState=UI_ALIGN;
                else if(settingsSel==9) { temp_mountType = mountType; uiState=UI_MOUNT; }
                else if(settingsSel==10) { temp_gearRatioAZ = gearRatioAZ; uiState=UI_RATIO_AZ; }
                else if(settingsSel==11) { temp_gearRatioALT = gearRatioALT; uiState=UI_RATIO_ALT; }
                else if(settingsSel==12) { syncDataFromMega(); editSel=0; uiState=UI_EDIT_TIME; }
                else if(settingsSel==13) { syncDataFromMega(); editSel=0; uiState=UI_EDIT_LOCATION; }
                else if(settingsSel==14) { temp_isEnglish = isEnglish; uiState=UI_LANGUAGE; }
                else if(settingsSel==15) { temp_gpsEnabled = gpsEnabled; uiState=UI_GPS; }
                else if(settingsSel==16) { temp_displayRaDec = displayRaDec; uiState=UI_COORD_MODE; }
            }
            break;

        case UI_SPEED:
            if(left)  { uiState=UI_SETTINGS; }
            if(up)    { temp_slewSpeed += 0.5; if(temp_slewSpeed>6.0) temp_slewSpeed=6.0; }
            if(down)  { temp_slewSpeed -= 0.5; if(temp_slewSpeed<0.5) temp_slewSpeed=0.5; }
            if(enter) {
                m_slewSpeed = temp_slewSpeed;
                cmd_setSpeed(m_slewSpeed);
                saveEEPROM();
                char buf[21]; snprintf(buf,21,"   %.1f deg/s OK   ",m_slewSpeed);
                showMessage("  VITESSE REGL.    ", buf, 1200, UI_SETTINGS);
            }
            break;

        case UI_ALIGN:
            {
                bool found = false;
                for (int i=0; i<BSC_COUNT; i++) {
                    StarObject s = getStarFromCatalog(i);
                    if (isVisible(s.ra, s.dec)) {
                        currentCat = CAT_BSC;
                        objectIndex = i;
                        selectCurrentObject();
                        isAlignWorkflow = true;
                        uiState = UI_OBJECT_INFO;
                        found = true;
                        break;
                    }
                }
                if (!found) {
                    showMessage(isEnglish ? " NO STAR FOUND  " : " AUCUNE ETOILE  ", " VISIBLE        ", 1500, UI_SETTINGS);
                }
            }
            break;
            
        case UI_ALIGN_CENTER:
            if(left)  { uiState=UI_MAIN; isAlignWorkflow = false; }
            if(enter) {
                double ra =selectedIsStar?selectedStar.ra  :selectedObj.ra;
                double dec=selectedIsStar?selectedStar.dec :selectedObj.dec;
                cmd_sync_on(ra, dec, false);
                showMessage(isEnglish ? "  SYNCHRONIZED  " : "  SYNCHRONISE   ", "                ", 1500, UI_MAIN);
                isAlignWorkflow = false;
            }
            break;

        case UI_PARKING:
            if(left)  { uiState=UI_SETTINGS; }
            if(up)    { parkSel=(parkSel-1+3)%3; }
            if(down)  { parkSel=(parkSel+1)%3; }
            if(enter) {
                if (parkSel == 0) { // Park
                    String sa = mega_cmd(":GQa#");
                    String sz = mega_cmd(":GQz#");
                    if (sa.length() > 0) m_parkAlt = sa.toFloat();
                    if (sz.length() > 0) m_parkAz = sz.toFloat();
                    cmd_parking();
                    isParkingWorkflow = true;
                    showMessage(" PARKING EN COURS..", "                    ", 1500, UI_SLEWING);
                } else if (parkSel == 1) { // Unpark
                    // :hR repond '1', ou '0' si une alarme est active
                    String r = mega_cmd(":hR");
                    if (r == "1") {
                        m_isPaused = false;
                        showMessage(isEnglish ? " MOUNT UNPARKED   " : " MONTURE DEPARQUEE", "                    ", 1500, UI_MAIN);
                    } else if (r == "0") {
                        showMessage(isEnglish ? "  !! IMPOSSIBLE !!  " : "  !! IMPOSSIBLE !!  ", isEnglish ? " Mount alarm       " : " Alarme monture    ", 2500, UI_MAIN);
                    } else {
                        showMessage(isEnglish ? "  !! IMPOSSIBLE !!  " : "  !! IMPOSSIBLE !!  ", isEnglish ? " No mount reply    " : " Pas de reponse    ", 2500, UI_MAIN);
                    }
                } else if (parkSel == 2) { // Set Pos
                    // Position courante -> position de parking (:BPa alt, :BPz az ; reponse "1#")
                    bool okAlt = (mega_cmd(":BPa" + String(m_currentAlt, 4)) == "1");
                    bool okAz  = (mega_cmd(":BPz" + String(m_currentAz, 4)) == "1");
                    if (okAlt && okAz)
                        showMessage(isEnglish ? " PARK POS SAVED   " : " POS PARK ENREG.  ", "                    ", 1500, UI_MAIN);
                    else
                        showMessage(isEnglish ? "  !! IMPOSSIBLE !!  " : "  !! IMPOSSIBLE !!  ", isEnglish ? " No mount reply    " : " Pas de reponse    ", 2500, UI_MAIN);
                }
            }
            break;


        case UI_MOUNT:
            if(left)  { uiState=UI_SETTINGS; }
            if(up||down) {
                temp_mountType = (temp_mountType + 1) % 3;
            }
            if(enter) {
                if (temp_mountType == 0) Serial1.print(":BMa#");
                else if (temp_mountType == 1) Serial1.print(":BMe#");
                else Serial1.print(":BMg#");
                showMessage(" MONTURE REGLEE   ", "                    ", 1200, UI_SETTINGS);
            }
            break;
            
        case UI_RATIO_AZ:
            if(left)  { uiState=UI_SETTINGS; }
            if(right) { ratioStep *= 10.0; if(ratioStep > 1000.0) ratioStep = 1.0; }
            if(up)    { temp_gearRatioAZ += ratioStep; }
            if(down)  { temp_gearRatioAZ -= ratioStep; if(temp_gearRatioAZ<1.0) temp_gearRatioAZ=1.0; }
            if(enter) {
                gearRatioAZ = temp_gearRatioAZ;
                Serial1.print(":BGa"); Serial1.print(gearRatioAZ); Serial1.print("#");
                saveEEPROM();
                showMessage((mountType == 0) ? " RATIO AZ REGLE   " : " RATIO RA REGLE   ", "                    ", 1200, UI_SETTINGS);
            }
            break;

        case UI_RATIO_ALT:
            if(left)  { uiState=UI_SETTINGS; }
            if(right) { ratioStep *= 10.0; if(ratioStep > 1000.0) ratioStep = 1.0; }
            if(up)    { temp_gearRatioALT += ratioStep; }
            if(down)  { temp_gearRatioALT -= ratioStep; if(temp_gearRatioALT<1.0) temp_gearRatioALT=1.0; }
            if(enter) {
                gearRatioALT = temp_gearRatioALT;
                Serial1.print(":BGe"); Serial1.print(gearRatioALT); Serial1.print("#");
                saveEEPROM();
                showMessage((mountType == 0) ? " RATIO ALT REGLE  " : " RATIO DEC REGLE  ", "                    ", 1200, UI_SETTINGS);
            }
            break;

        case UI_BEEP:
            if(left)  { uiState=UI_SETTINGS; }
            if(up||down) {
                temp_buzzerOn = !temp_buzzerOn;
            }
            if(enter) {
                buzzerOn = temp_buzzerOn;
                if (buzzerOn) Serial1.print(":Bb1#"); else Serial1.print(":Bb0#");
                saveEEPROM();
                showMessage(" BUZZER REGLE     ", "                    ", 1200, UI_SETTINGS);
            }
            break;

        case UI_EDIT_TIME:
            if(left) {
                if(editSel > 0) editSel--;
                else uiState=UI_SETTINGS;
            }
            if(right) {
                if(editSel < 5) editSel++;
            }
            if(up) {
                if(editSel==0) { dt_d++; if(dt_d>31) dt_d=1; }
                if(editSel==1) { dt_m++; if(dt_m>12) dt_m=1; }
                if(editSel==2) { dt_y++; if(dt_y>2099) dt_y=2024; }
                if(editSel==3) { dt_hr++; if(dt_hr>23) dt_hr=0; }
                if(editSel==4) { dt_min++; if(dt_min>59) dt_min=0; }
                if(editSel==5) { dt_sec++; if(dt_sec>59) dt_sec=0; }
            }
            if(down) {
                if(editSel==0) { dt_d--; if(dt_d<1) dt_d=31; }
                if(editSel==1) { dt_m--; if(dt_m<1) dt_m=12; }
                if(editSel==2) { dt_y--; if(dt_y<2024) dt_y=2099; }
                if(editSel==3) { dt_hr--; if(dt_hr<0) dt_hr=23; }
                if(editSel==4) { dt_min--; if(dt_min<0) dt_min=59; }
                if(editSel==5) { dt_sec--; if(dt_sec<0) dt_sec=59; }
            }
            if(enter) {
                char b[32];
                snprintf(b,32,":SC%02d/%02d/%02d",dt_m,dt_d,dt_y%100); mega_cmd(b);
                snprintf(b,32,":SL%02d:%02d:%02d",dt_hr,dt_min,dt_sec); mega_cmd(b);
                syncDataFromMega(); // Update current_lst from Mega
                timeFetched = true;
                showMessage("   HEURE SAUVEE   ", "", 1200, UI_SETTINGS);
            }
            break;

        case UI_EDIT_LOCATION:
            if(left) {
                if(editSel > 0) editSel--;
                else uiState=UI_SETTINGS;
            }
            if(right) {
                if(editSel < 1) editSel++;
            }
            if(up) {
                if(editSel==0) { obs_lat += 1.0; if(obs_lat>90.0) obs_lat=90.0; }
                if(editSel==1) { obs_lon += 1.0; if(obs_lon>180.0) obs_lon=180.0; }
            }
            if(down) {
                if(editSel==0) { obs_lat -= 1.0; if(obs_lat<-90.0) obs_lat=-90.0; }
                if(editSel==1) { obs_lon -= 1.0; if(obs_lon<-180.0) obs_lon=-180.0; }
            }
            if(enter) {
                saveEEPROM();
                sendLocationToMega();
                syncDataFromMega(); // Update current_lst from Mega (LST depends on longitude)
                showMessage("  LIEU SAUVEGARDE ", "", 1200, UI_SETTINGS);
            }
            break;
        case UI_CUSTOM_GOTO:
            if(left) {
                if(editSel > 0) editSel--;
                else uiState=UI_SETTINGS;
            }
            if(right) {
                if(editSel < 5) editSel++;
            }
            if(up) {
                if(editSel==0) { cgo_ra_h++; if(cgo_ra_h>23) cgo_ra_h=0; }
                if(editSel==1) { cgo_ra_m++; if(cgo_ra_m>59) cgo_ra_m=0; }
                if(editSel==2) { cgo_ra_s++; if(cgo_ra_s>59) cgo_ra_s=0; }
                if(editSel==3) { 
                    if (cgo_dec_d == 0) {
                        if (!cgo_dec_neg) { cgo_dec_d=1; }
                        else { cgo_dec_neg=false; cgo_dec_d=1; }
                    } else if (cgo_dec_d == 89 && !cgo_dec_neg) { cgo_dec_d=90; }
                    else if (cgo_dec_d == 90 && cgo_dec_neg) { cgo_dec_d=89; }
                    else {
                        if (!cgo_dec_neg) cgo_dec_d++;
                        else cgo_dec_d--;
                    }
                }
                if(editSel==4) { cgo_dec_m++; if(cgo_dec_m>59) cgo_dec_m=0; }
                if(editSel==5) { cgo_dec_s++; if(cgo_dec_s>59) cgo_dec_s=0; }
            }
            if(down) {
                if(editSel==0) { cgo_ra_h--; if(cgo_ra_h<0) cgo_ra_h=23; }
                if(editSel==1) { cgo_ra_m--; if(cgo_ra_m<0) cgo_ra_m=59; }
                if(editSel==2) { cgo_ra_s--; if(cgo_ra_s<0) cgo_ra_s=59; }
                if(editSel==3) { 
                    if (cgo_dec_d == 0) {
                        if (cgo_dec_neg) { cgo_dec_d=1; }
                        else { cgo_dec_neg=true; cgo_dec_d=1; }
                    } else if (cgo_dec_d == 89 && cgo_dec_neg) { cgo_dec_d=90; }
                    else if (cgo_dec_d == 90 && !cgo_dec_neg) { cgo_dec_d=89; }
                    else {
                        if (cgo_dec_neg) cgo_dec_d++;
                        else cgo_dec_d--;
                    }
                }
                if(editSel==4) { cgo_dec_m--; if(cgo_dec_m<0) cgo_dec_m=59; }
                if(editSel==5) { cgo_dec_s--; if(cgo_dec_s<0) cgo_dec_s=59; }
            }
            if(enter) {
                double ra = cgo_ra_h + cgo_ra_m/60.0 + cgo_ra_s/3600.0;
                double dec = cgo_dec_d + cgo_dec_m/60.0 + cgo_dec_s/3600.0;
                if (cgo_dec_neg) dec = -dec;
                if (!isVisible(ra, dec)) {
                    showMessage(isEnglish ? " BELOW HORIZON! " : " SOUS HORIZON ! ", "                ", 2000, UI_CUSTOM_GOTO);
                } else {
                    trackedObjectName = "Manuel";
                    cmd_goto(ra, dec, false);
                }
            }
            break;

        case UI_MOTOR_POWER:
            if(left)  { uiState=UI_SETTINGS; }
            if(up||down) {
                temp_motorPowerOn = !temp_motorPowerOn;
            }
            if(enter) {
                motorPowerOn = temp_motorPowerOn;
                if (motorPowerOn) {
                    Serial1.print(":ME#");
                    showMessage(isEnglish ? " MOTORS ENABLED " : " MOTEURS ACTIFS ", "                    ", 1200, UI_SETTINGS);
                } else {
                    Serial1.print(":MD#");
                    showMessage(isEnglish ? " MOTORS DISABLED" : " ALIM COUPEE    ", "                    ", 1200, UI_SETTINGS);
                }
            }
            break;

        case UI_LANGUAGE:
            if(left)  { uiState=UI_SETTINGS; }
            if(up||down) {
                temp_isEnglish = !temp_isEnglish;
            }
            if(enter||right) {
                isEnglish = temp_isEnglish;
                saveEEPROM();
                showMessage(isEnglish ? " LANGUAGE SAVED " : " LANGUE ENREG.  ", "                    ", 1200, UI_SETTINGS);
            }
            break;

        case UI_GPS:
            if(left)  { uiState=UI_SETTINGS; }
            if(up||down) {
                temp_gpsEnabled = !temp_gpsEnabled;
            }
            if(enter||right) {
                gpsEnabled = temp_gpsEnabled;
                Serial1.print(gpsEnabled ? ":bg1#" : ":bg0#");
                showMessage(" GPS REGLE        ", "                    ", 1200, UI_SETTINGS);
            }
            break;

        case UI_COORD_MODE:
            if(left)  { uiState=UI_SETTINGS; }
            if(up||down) {
                temp_displayRaDec = !temp_displayRaDec;
            }
            if(enter||right) {
                displayRaDec = temp_displayRaDec;
                saveEEPROM();
                showMessage(isEnglish ? " SAVED          " : " ENREGISTRE     ", "                    ", 1200, UI_SETTINGS);
            }
            break;

        case UI_MESSAGE:
            if(up||down||left||right||enter){
                uiState = (UIState)uiMsgReturn;
                uiMsgUntil = 0;
            }
            break;

        default: break;
    }
}

// ============================================================
// SECTION 12 : SETUP
static bool i2cPresent(uint8_t addr) {
    Wire.beginTransmission(addr);
    return Wire.endTransmission() == 0;
}

// ============================================================
void setup(){
    loadEEPROM();

    Serial1.begin(MEGA_BAUD);
    delay(500);

    for(int i=0;i<5;i++) pinMode(BTN_PINS[i],INPUT_PULLUP);

    Wire.begin();
    if (!i2cPresent(LCD_ADDR) && i2cPresent(LCD_ADDR_ALT))
        new (&lcd) LiquidCrystal_I2C(LCD_ADDR_ALT, 20, 4);   // même objet, autre adresse
    lcd.init();
    lcd.backlight();
    initCustomChars();

    lcd.clear();
    char buf[21];
    
    // Animation d'etoiles
    for(int i=0; i<20; i++) {
        char anim_buf1[21] = "                    ";
        char anim_buf2[21] = "                    ";
        anim_buf1[i] = '*';
        anim_buf2[19-i] = '*';
        lcdLine(0, anim_buf1);
        lcdLine(3, anim_buf2);
        delay(40);
    }
    
    lcdLine(1,"   * GoTo Mega *    ");
    lcdLine(2,"   Raquette v6.4    ");
    
    for(int i=19; i>=0; i--) {
        char anim_buf1[21] = "                    ";
        char anim_buf2[21] = "                    ";
        anim_buf1[i] = '*';
        anim_buf2[19-i] = '*';
        lcdLine(0, anim_buf1);
        lcdLine(3, anim_buf2);
        delay(40);
    }
    delay(500);
    
    lcdLine(0,"  Connexion serie...");
    snprintf(buf,21,"M%d N%d I%d C%d",
             MESSIER_COUNT, NGC_COUNT, IC_COUNT, CALDWELL_COUNT);
    lcdLine(3,buf);
    delay(1200);   

    for(int i=0;i<10;i++){
        String r=mega_cmd(":GVP");
        if(r.startsWith("OnStep") || r.startsWith("On-Step") || r.startsWith("GotoAndrivet") || r.startsWith("GoTo") || r.startsWith("goto")){
            m_online=true; break;
        }
        delay(600);
    }

    if(m_online){
        lcdLine(2,"  Monture OK v6!   ");
        delay(100);
        String sv=mega_cmd(":Bv");
        if(sv.length()>0) m_slewSpeed=sv.toInt()/10.0;
        
        delay(100);
        String s_bga = mega_cmd(":BGa");
        if(s_bga.length()>0) gearRatioAZ = s_bga.toFloat();
        
        delay(100);
        String s_bge = mega_cmd(":BGe");
        if(s_bge.length()>0) gearRatioALT = s_bge.toFloat();
        
        String s_bm = mega_cmd(":BM");
        if(s_bm.length()>0) mountType = s_bm.toInt();
        
        String s_bb = mega_cmd(":Bb");
        if(s_bb.length()>0) buzzerOn = (s_bb.toInt() > 0);
        
        saveEEPROM();
        
        syncDataFromMega();
        
        delay(900);
    } else {
        lcdLine(2,"  NON CONNECTEE    ");
        lcdLine(3,"  Verif cable/baud ");
        delay(3000);
    }

    lcd.clear();
    lcdNeedsRefresh=true;
}

// ============================================================
// SECTION 13 : LOOP
// ============================================================
unsigned long lastLcd = 0;

void loop(){

    handleButtons();

    if(uiState == UI_MESSAGE && millis() >= uiMsgUntil){
        uiState = (UIState)uiMsgReturn;
        lcdNeedsRefresh = true;
    }

    static unsigned long lastPoll=0;
    if(millis()-lastPoll >= POLL_INTERVAL_MS){
        pollMega();
        lastPoll=millis();

        if(uiState==UI_SLEWING && !m_isSlewing) {
            uiState=UI_MAIN;
            isParkingWorkflow = false;
        }
        lcdNeedsRefresh=true;
    }

    if(lcdNeedsRefresh && millis()-lastLcd>=200){
        refreshLcd();
        lastLcd=millis();
    }
}
